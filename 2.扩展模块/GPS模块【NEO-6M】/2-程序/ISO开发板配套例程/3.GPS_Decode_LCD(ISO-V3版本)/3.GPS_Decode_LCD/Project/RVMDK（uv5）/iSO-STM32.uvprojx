# Keil uVision project iSO-STM32.uvprojx, settings and files
target GPS (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: emWin_fatfs +hex
  c flags: Optim=2 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\STemWinLibrary522\inc;..\..\STemWinLibrary522\Config;..\..\User\lcd;..\..\User\SysTick;..\..\Demo;..\..\User\usart;..\..\User\sdcard;..\..\ff9;..\..\User\nmea_decode\include;..\..\User\gps
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c nema_decode_test.c
    ../../User/Led/: bsp_led.c
    ../../User/lcd/: bsp_ili9341_lcd.c bsp_touch.c bsp_gpio_spi.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/usart/: bsp_usart1.c bsp_usart2.c
    ../../User/sdcard/: bsp_sdio_sdcard.c
    ../../User/gps/: gps_config.c
  group ff9
    ../../ff9/: diskio.c ff.c
    ../../ff9/option/: ccsbcs.c
  group STemWin_V522
    ../../STemWinLibrary522/Lib/: STemWin522_CM3_Keil.lib
    ../../STemWinLibrary522/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../../STemWinLibrary522/OS/: GUI_X.c GUI_X_Touch_Analog.c
  group Demo
    ../../Demo/: GUIDEMO_Touch.c
  group nmealib
    ../../User/nmea_decode/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
  group DOC
    ../../Doc/: readme.txt
software components: CMSIS:CORE 4.1.0
