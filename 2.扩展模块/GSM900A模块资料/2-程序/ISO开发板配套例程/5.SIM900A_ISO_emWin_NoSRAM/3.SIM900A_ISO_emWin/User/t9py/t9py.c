
/***************T9拼音输入法汉字索引**********************/
/*                                                       */
/*                                                       */
/* 文件名称：.c                                          */
/* 文件标识：                                            */
/* 摘 要：                                               */
/*                                                       */
/* 当前版本：                                            */
/* 作 者：   magicchip                                   */
/* 完成日期：                                            */
/* 修改版本：                                            */
/*                                                       */
/*                                                       */
/*********************************************************/

//#include  "config.h"
#include "t9py.h"
//#include <windows.h>
#include <string.h>

char print_buf[200];

/* exact-width unsigned integer types */
//typedef unsigned          char uint8_t;
//typedef unsigned short     int uint16_t;
//typedef unsigned           int uint32_t;
//typedef unsigned       __int64 uint64;

struct t9PY_index
{
    const uint32_t t9PY;
    const uint8_t *PY;
    const uint8_t *PY_mb;
};

struct t9py_struct
{
	uint8_t  pysrf;       //输入法选项
	uint8_t  key_len;		//按键数	
	uint8_t  firstno;     //输入的第一个数字按键
	uint8_t  mblen;       //查出码表的长度
	uint8_t  mbtimes;     //码表切换的次数
	uint32_t t9py;		//数字按键组合,组合成16进制，比如按键246则为0x246
	const struct t9PY_index  *t9PY_addr;		//指向码表地址
};
struct  t9py_struct t9pyfun;  

/*******************************************************************************
**功能：拼音输入法汉字排列表
**创建：magicchip
**日期：20080509
*******************************************************************************/

#ifdef UTF8_CODE
/* UTF-8 编码*/

//const unsigned char PY_mb_space []={""};
const unsigned char PY_mb_space []={0x20,0x00};

//const unsigned char PY_mb_a     []={"啊阿呵吖嗄腌锕"};
const unsigned char PY_mb_a     []={0xe5,0x95,0x8a,0xe9,0x98,0xbf,0xe5,0x91,0xb5,0xe5,0x90,0x96,0xe5,0x97,0x84,0xe8,0x85,0x8c,0xe9,0x94,0x95,0x00};

//const unsigned char PY_mb_ai    []={"爱矮挨哎碍癌艾唉哀蔼隘埃皑呆嗌嫒瑷暧捱砹嗳锿霭"};
const unsigned char PY_mb_ai    []={0xe7,0x88,0xb1,0xe7,0x9f,0xae,0xe6,0x8c,0xa8,0xe5,0x93,0x8e,0xe7,0xa2,0x8d,0xe7,0x99,0x8c,0xe8,0x89,0xbe,0xe5,0x94,0x89,0xe5,0x93,0x80,0xe8,0x94,0xbc,0xe9,0x9a,0x98,0xe5,0x9f,0x83,0xe7,0x9a,0x91,0xe5,0x91,0x86,0xe5,0x97,0x8c,0xe5,0xab,0x92,0xe7,0x91,0xb7,0xe6,0x9a,0xa7,0xe6,0x8d,0xb1,0xe7,0xa0,0xb9,0xe5,0x97,0xb3,0xe9,0x94,0xbf,0xe9,0x9c,0xad,0x00};

//const unsigned char PY_mb_an    []={"按安暗岸俺案鞍氨胺厂广庵揞犴铵桉谙鹌埯黯"};
const unsigned char PY_mb_an    []={0xe6,0x8c,0x89,0xe5,0xae,0x89,0xe6,0x9a,0x97,0xe5,0xb2,0xb8,0xe4,0xbf,0xba,0xe6,0xa1,0x88,0xe9,0x9e,0x8d,0xe6,0xb0,0xa8,0xe8,0x83,0xba,0xe5,0x8e,0x82,0xe5,0xb9,0xbf,0xe5,0xba,0xb5,0xe6,0x8f,0x9e,0xe7,0x8a,0xb4,0xe9,0x93,0xb5,0xe6,0xa1,0x89,0xe8,0xb0,0x99,0xe9,0xb9,0x8c,0xe5,0x9f,0xaf,0xe9,0xbb,0xaf,0x00};

//const unsigned char PY_mb_ang   []={"昂肮盎仰"};
const unsigned char PY_mb_ang   []={0xe6,0x98,0x82,0xe8,0x82,0xae,0xe7,0x9b,0x8e,0xe4,0xbb,0xb0,0x00};

//const unsigned char PY_mb_ao    []={"袄凹傲奥熬懊敖翱澳嚣拗媪廒骜嗷坳遨聱螯獒鏊鳌鏖"};
const unsigned char PY_mb_ao    []={0xe8,0xa2,0x84,0xe5,0x87,0xb9,0xe5,0x82,0xb2,0xe5,0xa5,0xa5,0xe7,0x86,0xac,0xe6,0x87,0x8a,0xe6,0x95,0x96,0xe7,0xbf,0xb1,0xe6,0xbe,0xb3,0xe5,0x9a,0xa3,0xe6,0x8b,0x97,0xe5,0xaa,0xaa,0xe5,0xbb,0x92,0xe9,0xaa,0x9c,0xe5,0x97,0xb7,0xe5,0x9d,0xb3,0xe9,0x81,0xa8,0xe8,0x81,0xb1,0xe8,0x9e,0xaf,0xe7,0x8d,0x92,0xe9,0x8f,0x8a,0xe9,0xb3,0x8c,0xe9,0x8f,0x96,0x00};

//const unsigned char PY_mb_ba    []={"把八吧爸拔罢跋巴芭扒坝霸叭靶笆疤耙捌粑茇岜鲅钯魃"};
const unsigned char PY_mb_ba    []={0xe6,0x8a,0x8a,0xe5,0x85,0xab,0xe5,0x90,0xa7,0xe7,0x88,0xb8,0xe6,0x8b,0x94,0xe7,0xbd,0xa2,0xe8,0xb7,0x8b,0xe5,0xb7,0xb4,0xe8,0x8a,0xad,0xe6,0x89,0x92,0xe5,0x9d,0x9d,0xe9,0x9c,0xb8,0xe5,0x8f,0xad,0xe9,0x9d,0xb6,0xe7,0xac,0x86,0xe7,0x96,0xa4,0xe8,0x80,0x99,0xe6,0x8d,0x8c,0xe7,0xb2,0x91,0xe8,0x8c,0x87,0xe5,0xb2,0x9c,0xe9,0xb2,0x85,0xe9,0x92,0xaf,0xe9,0xad,0x83,0x00};

//const unsigned char PY_mb_bai   []={"百白摆败柏拜佰伯稗捭呗掰"};
const unsigned char PY_mb_bai   []={0xe7,0x99,0xbe,0xe7,0x99,0xbd,0xe6,0x91,0x86,0xe8,0xb4,0xa5,0xe6,0x9f,0x8f,0xe6,0x8b,0x9c,0xe4,0xbd,0xb0,0xe4,0xbc,0xaf,0xe7,0xa8,0x97,0xe6,0x8d,0xad,0xe5,0x91,0x97,0xe6,0x8e,0xb0,0x00};

//const unsigned char PY_mb_ban   []={"半办班般拌搬版斑板伴扳扮瓣颁绊癍坂钣舨阪"};
const unsigned char PY_mb_ban   []={0xe5,0x8d,0x8a,0xe5,0x8a,0x9e,0xe7,0x8f,0xad,0xe8,0x88,0xac,0xe6,0x8b,0x8c,0xe6,0x90,0xac,0xe7,0x89,0x88,0xe6,0x96,0x91,0xe6,0x9d,0xbf,0xe4,0xbc,0xb4,0xe6,0x89,0xb3,0xe6,0x89,0xae,0xe7,0x93,0xa3,0xe9,0xa2,0x81,0xe7,0xbb,0x8a,0xe7,0x99,0x8d,0xe5,0x9d,0x82,0xe9,0x92,0xa3,0xe8,0x88,0xa8,0xe9,0x98,0xaa,0x00};

//const unsigned char PY_mb_bang  []={"帮棒绑磅镑邦榜蚌傍梆膀谤浜蒡"};
const unsigned char PY_mb_bang  []={0xe5,0xb8,0xae,0xe6,0xa3,0x92,0xe7,0xbb,0x91,0xe7,0xa3,0x85,0xe9,0x95,0x91,0xe9,0x82,0xa6,0xe6,0xa6,0x9c,0xe8,0x9a,0x8c,0xe5,0x82,0x8d,0xe6,0xa2,0x86,0xe8,0x86,0x80,0xe8,0xb0,0xa4,0xe6,0xb5,0x9c,0xe8,0x92,0xa1,0x00};

//const unsigned char PY_mb_bao   []={"包抱报饱保暴薄宝爆剥豹刨雹褒堡苞胞鲍炮瀑龅孢煲褓鸨趵葆"};
const unsigned char PY_mb_bao   []={0xe5,0x8c,0x85,0xe6,0x8a,0xb1,0xe6,0x8a,0xa5,0xe9,0xa5,0xb1,0xe4,0xbf,0x9d,0xe6,0x9a,0xb4,0xe8,0x96,0x84,0xe5,0xae,0x9d,0xe7,0x88,0x86,0xe5,0x89,0xa5,0xe8,0xb1,0xb9,0xe5,0x88,0xa8,0xe9,0x9b,0xb9,0xe8,0xa4,0x92,0xe5,0xa0,0xa1,0xe8,0x8b,0x9e,0xe8,0x83,0x9e,0xe9,0xb2,0x8d,0xe7,0x82,0xae,0xe7,0x80,0x91,0xe9,0xbe,0x85,0xe5,0xad,0xa2,0xe7,0x85,0xb2,0xe8,0xa4,0x93,0xe9,0xb8,0xa8,0xe8,0xb6,0xb5,0xe8,0x91,0x86,0x00};

//const unsigned char PY_mb_bei   []={"被北倍杯背悲备碑卑贝辈钡焙狈惫臂褙悖蓓鹎鐾呗"};
const unsigned char PY_mb_bei   []={0xe8,0xa2,0xab,0xe5,0x8c,0x97,0xe5,0x80,0x8d,0xe6,0x9d,0xaf,0xe8,0x83,0x8c,0xe6,0x82,0xb2,0xe5,0xa4,0x87,0xe7,0xa2,0x91,0xe5,0x8d,0x91,0xe8,0xb4,0x9d,0xe8,0xbe,0x88,0xe9,0x92,0xa1,0xe7,0x84,0x99,0xe7,0x8b,0x88,0xe6,0x83,0xab,0xe8,0x87,0x82,0xe8,0xa4,0x99,0xe6,0x82,0x96,0xe8,0x93,0x93,0xe9,0xb9,0x8e,0xe9,0x90,0xbe,0xe5,0x91,0x97,0x00};

//const unsigned char PY_mb_ben   []={"本奔苯笨夯锛贲畚坌"};
const unsigned char PY_mb_ben   []={0xe6,0x9c,0xac,0xe5,0xa5,0x94,0xe8,0x8b,0xaf,0xe7,0xac,0xa8,0xe5,0xa4,0xaf,0xe9,0x94,0x9b,0xe8,0xb4,0xb2,0xe7,0x95,0x9a,0xe5,0x9d,0x8c,0x00};

//const unsigned char PY_mb_beng  []={"蹦绷甭崩迸蚌泵甏嘣"};
const unsigned char PY_mb_beng  []={0xe8,0xb9,0xa6,0xe7,0xbb,0xb7,0xe7,0x94,0xad,0xe5,0xb4,0xa9,0xe8,0xbf,0xb8,0xe8,0x9a,0x8c,0xe6,0xb3,0xb5,0xe7,0x94,0x8f,0xe5,0x98,0xa3,0x00};

//const unsigned char PY_mb_bi    []={"比笔闭鼻碧必避逼毕臂彼鄙壁蓖币弊辟蔽毙庇敝陛毖痹秘泌秕薜荸芘萆匕裨畀俾嬖狴筚箅篦舭荜襞庳铋跸吡愎贲滗濞璧哔髀弼妣婢"};
const unsigned char PY_mb_bi    []={0xe6,0xaf,0x94,0xe7,0xac,0x94,0xe9,0x97,0xad,0xe9,0xbc,0xbb,0xe7,0xa2,0xa7,0xe5,0xbf,0x85,0xe9,0x81,0xbf,0xe9,0x80,0xbc,0xe6,0xaf,0x95,0xe8,0x87,0x82,0xe5,0xbd,0xbc,0xe9,0x84,0x99,0xe5,0xa3,0x81,0xe8,0x93,0x96,0xe5,0xb8,0x81,0xe5,0xbc,0x8a,0xe8,0xbe,0x9f,0xe8,0x94,0xbd,0xe6,0xaf,0x99,0xe5,0xba,0x87,0xe6,0x95,0x9d,0xe9,0x99,0x9b,0xe6,0xaf,0x96,0xe7,0x97,0xb9,0xe7,0xa7,0x98,0xe6,0xb3,0x8c,0xe7,0xa7,0x95,0xe8,0x96,0x9c,0xe8,0x8d,0xb8,0xe8,0x8a,0x98,0xe8,0x90,0x86,0xe5,0x8c,0x95,0xe8,0xa3,0xa8,0xe7,0x95,0x80,0xe4,0xbf,0xbe,0xe5,0xac,0x96,0xe7,0x8b,0xb4,0xe7,0xad,0x9a,0xe7,0xae,0x85,0xe7,0xaf,0xa6,0xe8,0x88,0xad,0xe8,0x8d,0x9c,0xe8,0xa5,0x9e,0xe5,0xba,0xb3,0xe9,0x93,0x8b,0xe8,0xb7,0xb8,0xe5,0x90,0xa1,0xe6,0x84,0x8e,0xe8,0xb4,0xb2,0xe6,0xbb,0x97,0xe6,0xbf,0x9e,0xe7,0x92,0xa7,0xe5,0x93,0x94,0xe9,0xab,0x80,0xe5,0xbc,0xbc,0xe5,0xa6,0xa3,0xe5,0xa9,0xa2,0x00};

//const unsigned char PY_mb_bian  []={"边变便遍编辩扁贬鞭卞辨辫忭砭匾汴碥蝙褊鳊笾苄窆弁缏"};
const unsigned char PY_mb_bian  []={0xe8,0xbe,0xb9,0xe5,0x8f,0x98,0xe4,0xbe,0xbf,0xe9,0x81,0x8d,0xe7,0xbc,0x96,0xe8,0xbe,0xa9,0xe6,0x89,0x81,0xe8,0xb4,0xac,0xe9,0x9e,0xad,0xe5,0x8d,0x9e,0xe8,0xbe,0xa8,0xe8,0xbe,0xab,0xe5,0xbf,0xad,0xe7,0xa0,0xad,0xe5,0x8c,0xbe,0xe6,0xb1,0xb4,0xe7,0xa2,0xa5,0xe8,0x9d,0x99,0xe8,0xa4,0x8a,0xe9,0xb3,0x8a,0xe7,0xac,0xbe,0xe8,0x8b,0x84,0xe7,0xaa,0x86,0xe5,0xbc,0x81,0xe7,0xbc,0x8f,0x00};

//const unsigned char PY_mb_biao  []={"表标彪膘杓婊飑飙鳔瘭飚镳裱骠镖"};
const unsigned char PY_mb_biao  []={0xe8,0xa1,0xa8,0xe6,0xa0,0x87,0xe5,0xbd,0xaa,0xe8,0x86,0x98,0xe6,0x9d,0x93,0xe5,0xa9,0x8a,0xe9,0xa3,0x91,0xe9,0xa3,0x99,0xe9,0xb3,0x94,0xe7,0x98,0xad,0xe9,0xa3,0x9a,0xe9,0x95,0xb3,0xe8,0xa3,0xb1,0xe9,0xaa,0xa0,0xe9,0x95,0x96,0x00};

//const unsigned char PY_mb_bie   []={"别憋鳖瘪蹩"};
const unsigned char PY_mb_bie   []={0xe5,0x88,0xab,0xe6,0x86,0x8b,0xe9,0xb3,0x96,0xe7,0x98,0xaa,0xe8,0xb9,0xa9,0x00};

//const unsigned char PY_mb_bin   []={"宾濒摈彬斌滨豳膑殡缤髌傧槟鬓镔玢"};
const unsigned char PY_mb_bin   []={0xe5,0xae,0xbe,0xe6,0xbf,0x92,0xe6,0x91,0x88,0xe5,0xbd,0xac,0xe6,0x96,0x8c,0xe6,0xbb,0xa8,0xe8,0xb1,0xb3,0xe8,0x86,0x91,0xe6,0xae,0xa1,0xe7,0xbc,0xa4,0xe9,0xab,0x8c,0xe5,0x82,0xa7,0xe6,0xa7,0x9f,0xe9,0xac,0x93,0xe9,0x95,0x94,0xe7,0x8e,0xa2,0x00};

//const unsigned char PY_mb_bing  []={"并病兵冰丙饼屏秉柄炳摒槟禀邴"};
const unsigned char PY_mb_bing  []={0xe5,0xb9,0xb6,0xe7,0x97,0x85,0xe5,0x85,0xb5,0xe5,0x86,0xb0,0xe4,0xb8,0x99,0xe9,0xa5,0xbc,0xe5,0xb1,0x8f,0xe7,0xa7,0x89,0xe6,0x9f,0x84,0xe7,0x82,0xb3,0xe6,0x91,0x92,0xe6,0xa7,0x9f,0xe7,0xa6,0x80,0xe9,0x82,0xb4,0x00};

//const unsigned char PY_mb_bo    []={"拨波播泊博伯驳玻剥薄勃菠钵搏脖帛般柏舶渤铂箔膊魄卜礴跛檗亳鹁踣啵蕃簸钹饽擘"};
const unsigned char PY_mb_bo    []={0xe6,0x8b,0xa8,0xe6,0xb3,0xa2,0xe6,0x92,0xad,0xe6,0xb3,0x8a,0xe5,0x8d,0x9a,0xe4,0xbc,0xaf,0xe9,0xa9,0xb3,0xe7,0x8e,0xbb,0xe5,0x89,0xa5,0xe8,0x96,0x84,0xe5,0x8b,0x83,0xe8,0x8f,0xa0,0xe9,0x92,0xb5,0xe6,0x90,0x8f,0xe8,0x84,0x96,0xe5,0xb8,0x9b,0xe8,0x88,0xac,0xe6,0x9f,0x8f,0xe8,0x88,0xb6,0xe6,0xb8,0xa4,0xe9,0x93,0x82,0xe7,0xae,0x94,0xe8,0x86,0x8a,0xe9,0xad,0x84,0xe5,0x8d,0x9c,0xe7,0xa4,0xb4,0xe8,0xb7,0x9b,0xe6,0xaa,0x97,0xe4,0xba,0xb3,0xe9,0xb9,0x81,0xe8,0xb8,0xa3,0xe5,0x95,0xb5,0xe8,0x95,0x83,0xe7,0xb0,0xb8,0xe9,0x92,0xb9,0xe9,0xa5,0xbd,0xe6,0x93,0x98,0x00};

//const unsigned char PY_mb_bu    []={"不步补布部捕卜簿哺堡埠怖埔瓿逋晡钸钚醭卟"};
const unsigned char PY_mb_bu    []={0xe4,0xb8,0x8d,0xe6,0xad,0xa5,0xe8,0xa1,0xa5,0xe5,0xb8,0x83,0xe9,0x83,0xa8,0xe6,0x8d,0x95,0xe5,0x8d,0x9c,0xe7,0xb0,0xbf,0xe5,0x93,0xba,0xe5,0xa0,0xa1,0xe5,0x9f,0xa0,0xe6,0x80,0x96,0xe5,0x9f,0x94,0xe7,0x93,0xbf,0xe9,0x80,0x8b,0xe6,0x99,0xa1,0xe9,0x92,0xb8,0xe9,0x92,0x9a,0xe9,0x86,0xad,0xe5,0x8d,0x9f,0x00};

//const unsigned char PY_mb_ca    []={"擦拆礤嚓"};
const unsigned char PY_mb_ca    []={0xe6,0x93,0xa6,0xe6,0x8b,0x86,0xe7,0xa4,0xa4,0xe5,0x9a,0x93,0x00};

//const unsigned char PY_mb_cai   []={"猜才材财裁采彩睬踩菜蔡"};
const unsigned char PY_mb_cai   []={0xe7,0x8c,0x9c,0xe6,0x89,0x8d,0xe6,0x9d,0x90,0xe8,0xb4,0xa2,0xe8,0xa3,0x81,0xe9,0x87,0x87,0xe5,0xbd,0xa9,0xe7,0x9d,0xac,0xe8,0xb8,0xa9,0xe8,0x8f,0x9c,0xe8,0x94,0xa1,0x00};

//const unsigned char PY_mb_can   []={"蚕残掺参惨惭餐灿骖璨孱黪粲"};
const unsigned char PY_mb_can   []={0xe8,0x9a,0x95,0xe6,0xae,0x8b,0xe6,0x8e,0xba,0xe5,0x8f,0x82,0xe6,0x83,0xa8,0xe6,0x83,0xad,0xe9,0xa4,0x90,0xe7,0x81,0xbf,0xe9,0xaa,0x96,0xe7,0x92,0xa8,0xe5,0xad,0xb1,0xe9,0xbb,0xaa,0xe7,0xb2,0xb2,0x00};

//const unsigned char PY_mb_cang  []={"藏仓沧舱苍伧"};
const unsigned char PY_mb_cang  []={0xe8,0x97,0x8f,0xe4,0xbb,0x93,0xe6,0xb2,0xa7,0xe8,0x88,0xb1,0xe8,0x8b,0x8d,0xe4,0xbc,0xa7,0x00};

//const unsigned char PY_mb_cao   []={"草操曹槽糙嘈艚螬漕"};
const unsigned char PY_mb_cao   []={0xe8,0x8d,0x89,0xe6,0x93,0x8d,0xe6,0x9b,0xb9,0xe6,0xa7,0xbd,0xe7,0xb3,0x99,0xe5,0x98,0x88,0xe8,0x89,0x9a,0xe8,0x9e,0xac,0xe6,0xbc,0x95,0x00};

//const unsigned char PY_mb_ce    []={"册侧策测厕恻"};
const unsigned char PY_mb_ce    []={0xe5,0x86,0x8c,0xe4,0xbe,0xa7,0xe7,0xad,0x96,0xe6,0xb5,0x8b,0xe5,0x8e,0x95,0xe6,0x81,0xbb,0x00};

//const unsigned char PY_mb_cen   []={"参岑涔"};
const unsigned char PY_mb_cen   []={0xe5,0x8f,0x82,0xe5,0xb2,0x91,0xe6,0xb6,0x94,0x00};

//const unsigned char PY_mb_ceng  []={"曾层蹭噌"};
const unsigned char PY_mb_ceng  []={0xe6,0x9b,0xbe,0xe5,0xb1,0x82,0xe8,0xb9,0xad,0xe5,0x99,0x8c,0x00};

//const unsigned char PY_mb_cha   []={"查插叉茶差岔搽察茬碴刹诧楂槎镲衩汊馇檫姹杈锸嚓"};
const unsigned char PY_mb_cha   []={0xe6,0x9f,0xa5,0xe6,0x8f,0x92,0xe5,0x8f,0x89,0xe8,0x8c,0xb6,0xe5,0xb7,0xae,0xe5,0xb2,0x94,0xe6,0x90,0xbd,0xe5,0xaf,0x9f,0xe8,0x8c,0xac,0xe7,0xa2,0xb4,0xe5,0x88,0xb9,0xe8,0xaf,0xa7,0xe6,0xa5,0x82,0xe6,0xa7,0x8e,0xe9,0x95,0xb2,0xe8,0xa1,0xa9,0xe6,0xb1,0x8a,0xe9,0xa6,0x87,0xe6,0xaa,0xab,0xe5,0xa7,0xb9,0xe6,0x9d,0x88,0xe9,0x94,0xb8,0xe5,0x9a,0x93,0x00};

//const unsigned char PY_mb_chai  []={"菜柴拆差豺钗瘥虿侪"};
const unsigned char PY_mb_chai  []={0xe8,0x8f,0x9c,0xe6,0x9f,0xb4,0xe6,0x8b,0x86,0xe5,0xb7,0xae,0xe8,0xb1,0xba,0xe9,0x92,0x97,0xe7,0x98,0xa5,0xe8,0x99,0xbf,0xe4,0xbe,0xaa,0x00};

//const unsigned char PY_mb_chan  []={"产缠掺搀阐颤铲谗蝉单馋觇婵蒇谄冁廛孱蟾羼镡忏潺禅骣躔澶"};
const unsigned char PY_mb_chan  []={0xe4,0xba,0xa7,0xe7,0xbc,0xa0,0xe6,0x8e,0xba,0xe6,0x90,0x80,0xe9,0x98,0x90,0xe9,0xa2,0xa4,0xe9,0x93,0xb2,0xe8,0xb0,0x97,0xe8,0x9d,0x89,0xe5,0x8d,0x95,0xe9,0xa6,0x8b,0xe8,0xa7,0x87,0xe5,0xa9,0xb5,0xe8,0x92,0x87,0xe8,0xb0,0x84,0xe5,0x86,0x81,0xe5,0xbb,0x9b,0xe5,0xad,0xb1,0xe8,0x9f,0xbe,0xe7,0xbe,0xbc,0xe9,0x95,0xa1,0xe5,0xbf,0x8f,0xe6,0xbd,0xba,0xe7,0xa6,0x85,0xe9,0xaa,0xa3,0xe8,0xba,0x94,0xe6,0xbe,0xb6,0x00};

//const unsigned char PY_mb_chang []={"长唱常场厂尝肠畅昌敞倡偿猖裳鲳氅菖惝嫦徜鬯阊怅伥昶苌娼"};
const unsigned char PY_mb_chang []={0xe9,0x95,0xbf,0xe5,0x94,0xb1,0xe5,0xb8,0xb8,0xe5,0x9c,0xba,0xe5,0x8e,0x82,0xe5,0xb0,0x9d,0xe8,0x82,0xa0,0xe7,0x95,0x85,0xe6,0x98,0x8c,0xe6,0x95,0x9e,0xe5,0x80,0xa1,0xe5,0x81,0xbf,0xe7,0x8c,0x96,0xe8,0xa3,0xb3,0xe9,0xb2,0xb3,0xe6,0xb0,0x85,0xe8,0x8f,0x96,0xe6,0x83,0x9d,0xe5,0xab,0xa6,0xe5,0xbe,0x9c,0xe9,0xac,0xaf,0xe9,0x98,0x8a,0xe6,0x80,0x85,0xe4,0xbc,0xa5,0xe6,0x98,0xb6,0xe8,0x8b,0x8c,0xe5,0xa8,0xbc,0x00};

//const unsigned char PY_mb_chao  []={"朝抄超吵潮巢炒嘲剿绰钞怊焯耖晁"};
const unsigned char PY_mb_chao  []={0xe6,0x9c,0x9d,0xe6,0x8a,0x84,0xe8,0xb6,0x85,0xe5,0x90,0xb5,0xe6,0xbd,0xae,0xe5,0xb7,0xa2,0xe7,0x82,0x92,0xe5,0x98,0xb2,0xe5,0x89,0xbf,0xe7,0xbb,0xb0,0xe9,0x92,0x9e,0xe6,0x80,0x8a,0xe7,0x84,0xaf,0xe8,0x80,0x96,0xe6,0x99,0x81,0x00};

//const unsigned char PY_mb_che   []={"车撤扯掣彻尺澈坼砗"};
const unsigned char PY_mb_che   []={0xe8,0xbd,0xa6,0xe6,0x92,0xa4,0xe6,0x89,0xaf,0xe6,0x8e,0xa3,0xe5,0xbd,0xbb,0xe5,0xb0,0xba,0xe6,0xbe,0x88,0xe5,0x9d,0xbc,0xe7,0xa0,0x97,0x00};

//const unsigned char PY_mb_chen  []={"趁称辰臣尘晨沉陈衬橙忱郴榇抻谌碜谶宸龀嗔伧琛"};
const unsigned char PY_mb_chen  []={0xe8,0xb6,0x81,0xe7,0xa7,0xb0,0xe8,0xbe,0xb0,0xe8,0x87,0xa3,0xe5,0xb0,0x98,0xe6,0x99,0xa8,0xe6,0xb2,0x89,0xe9,0x99,0x88,0xe8,0xa1,0xac,0xe6,0xa9,0x99,0xe5,0xbf,0xb1,0xe9,0x83,0xb4,0xe6,0xa6,0x87,0xe6,0x8a,0xbb,0xe8,0xb0,0x8c,0xe7,0xa2,0x9c,0xe8,0xb0,0xb6,0xe5,0xae,0xb8,0xe9,0xbe,0x80,0xe5,0x97,0x94,0xe4,0xbc,0xa7,0xe7,0x90,0x9b,0x00};

//const unsigned char PY_mb_cheng []={"成乘盛撑称城程呈诚惩逞骋澄橙承塍柽埕铖噌铛酲晟裎枨蛏丞瞠"};
const unsigned char PY_mb_cheng []={0xe6,0x88,0x90,0xe4,0xb9,0x98,0xe7,0x9b,0x9b,0xe6,0x92,0x91,0xe7,0xa7,0xb0,0xe5,0x9f,0x8e,0xe7,0xa8,0x8b,0xe5,0x91,0x88,0xe8,0xaf,0x9a,0xe6,0x83,0xa9,0xe9,0x80,0x9e,0xe9,0xaa,0x8b,0xe6,0xbe,0x84,0xe6,0xa9,0x99,0xe6,0x89,0xbf,0xe5,0xa1,0x8d,0xe6,0x9f,0xbd,0xe5,0x9f,0x95,0xe9,0x93,0x96,0xe5,0x99,0x8c,0xe9,0x93,0x9b,0xe9,0x85,0xb2,0xe6,0x99,0x9f,0xe8,0xa3,0x8e,0xe6,0x9e,0xa8,0xe8,0x9b,0x8f,0xe4,0xb8,0x9e,0xe7,0x9e,0xa0,0x00};

//const unsigned char PY_mb_chi   []={"吃尺迟池翅痴赤齿耻持斥侈弛驰炽匙踟坻茌墀饬媸豉褫敕哧瘛蚩啻鸱眵螭篪魑叱彳笞嗤"};
const unsigned char PY_mb_chi   []={0xe5,0x90,0x83,0xe5,0xb0,0xba,0xe8,0xbf,0x9f,0xe6,0xb1,0xa0,0xe7,0xbf,0x85,0xe7,0x97,0xb4,0xe8,0xb5,0xa4,0xe9,0xbd,0xbf,0xe8,0x80,0xbb,0xe6,0x8c,0x81,0xe6,0x96,0xa5,0xe4,0xbe,0x88,0xe5,0xbc,0x9b,0xe9,0xa9,0xb0,0xe7,0x82,0xbd,0xe5,0x8c,0x99,0xe8,0xb8,0x9f,0xe5,0x9d,0xbb,0xe8,0x8c,0x8c,0xe5,0xa2,0x80,0xe9,0xa5,0xac,0xe5,0xaa,0xb8,0xe8,0xb1,0x89,0xe8,0xa4,0xab,0xe6,0x95,0x95,0xe5,0x93,0xa7,0xe7,0x98,0x9b,0xe8,0x9a,0xa9,0xe5,0x95,0xbb,0xe9,0xb8,0xb1,0xe7,0x9c,0xb5,0xe8,0x9e,0xad,0xe7,0xaf,0xaa,0xe9,0xad,0x91,0xe5,0x8f,0xb1,0xe5,0xbd,0xb3,0xe7,0xac,0x9e,0xe5,0x97,0xa4,0x00};

//const unsigned char PY_mb_chong []={"冲重虫充宠崇涌种艟忡舂铳憧茺"};
const unsigned char PY_mb_chong []={0xe5,0x86,0xb2,0xe9,0x87,0x8d,0xe8,0x99,0xab,0xe5,0x85,0x85,0xe5,0xae,0xa0,0xe5,0xb4,0x87,0xe6,0xb6,0x8c,0xe7,0xa7,0x8d,0xe8,0x89,0x9f,0xe5,0xbf,0xa1,0xe8,0x88,0x82,0xe9,0x93,0xb3,0xe6,0x86,0xa7,0xe8,0x8c,0xba,0x00};

//const unsigned char PY_mb_chou  []={"抽愁臭仇丑稠绸酬筹踌畴瞅惆俦帱瘳雠"};
const unsigned char PY_mb_chou  []={0xe6,0x8a,0xbd,0xe6,0x84,0x81,0xe8,0x87,0xad,0xe4,0xbb,0x87,0xe4,0xb8,0x91,0xe7,0xa8,0xa0,0xe7,0xbb,0xb8,0xe9,0x85,0xac,0xe7,0xad,0xb9,0xe8,0xb8,0x8c,0xe7,0x95,0xb4,0xe7,0x9e,0x85,0xe6,0x83,0x86,0xe4,0xbf,0xa6,0xe5,0xb8,0xb1,0xe7,0x98,0xb3,0xe9,0x9b,0xa0,0x00};

//const unsigned char PY_mb_chu   []={"出处初锄除触橱楚础储畜滁矗搐躇厨雏楮杵刍怵绌亍憷蹰黜蜍樗"};
const unsigned char PY_mb_chu   []={0xe5,0x87,0xba,0xe5,0xa4,0x84,0xe5,0x88,0x9d,0xe9,0x94,0x84,0xe9,0x99,0xa4,0xe8,0xa7,0xa6,0xe6,0xa9,0xb1,0xe6,0xa5,0x9a,0xe7,0xa1,0x80,0xe5,0x82,0xa8,0xe7,0x95,0x9c,0xe6,0xbb,0x81,0xe7,0x9f,0x97,0xe6,0x90,0x90,0xe8,0xba,0x87,0xe5,0x8e,0xa8,0xe9,0x9b,0x8f,0xe6,0xa5,0xae,0xe6,0x9d,0xb5,0xe5,0x88,0x8d,0xe6,0x80,0xb5,0xe7,0xbb,0x8c,0xe4,0xba,0x8d,0xe6,0x86,0xb7,0xe8,0xb9,0xb0,0xe9,0xbb,0x9c,0xe8,0x9c,0x8d,0xe6,0xa8,0x97,0x00};

//const unsigned char PY_mb_chuai []={"揣膪啜嘬搋踹"};
const unsigned char PY_mb_chuai []={0xe6,0x8f,0xa3,0xe8,0x86,0xaa,0xe5,0x95,0x9c,0xe5,0x98,0xac,0xe6,0x90,0x8b,0xe8,0xb8,0xb9,0x00};

//const unsigned char PY_mb_chuan []={"穿船传串川喘椽氚遄钏舡舛巛"};
const unsigned char PY_mb_chuan []={0xe7,0xa9,0xbf,0xe8,0x88,0xb9,0xe4,0xbc,0xa0,0xe4,0xb8,0xb2,0xe5,0xb7,0x9d,0xe5,0x96,0x98,0xe6,0xa4,0xbd,0xe6,0xb0,0x9a,0xe9,0x81,0x84,0xe9,0x92,0x8f,0xe8,0x88,0xa1,0xe8,0x88,0x9b,0xe5,0xb7,0x9b,0x00};

//const unsigned char PY_mb_chuang[]={"窗床闯创疮幢怆"};
const unsigned char PY_mb_chuang[]={0xe7,0xaa,0x97,0xe5,0xba,0x8a,0xe9,0x97,0xaf,0xe5,0x88,0x9b,0xe7,0x96,0xae,0xe5,0xb9,0xa2,0xe6,0x80,0x86,0x00};

//const unsigned char PY_mb_chui  []={"吹垂炊锤捶椎槌棰陲"};
const unsigned char PY_mb_chui  []={0xe5,0x90,0xb9,0xe5,0x9e,0x82,0xe7,0x82,0x8a,0xe9,0x94,0xa4,0xe6,0x8d,0xb6,0xe6,0xa4,0x8e,0xe6,0xa7,0x8c,0xe6,0xa3,0xb0,0xe9,0x99,0xb2,0x00};

//const unsigned char PY_mb_chun  []={"春唇纯蠢醇淳椿蝽莼鹑"};
const unsigned char PY_mb_chun  []={0xe6,0x98,0xa5,0xe5,0x94,0x87,0xe7,0xba,0xaf,0xe8,0xa0,0xa2,0xe9,0x86,0x87,0xe6,0xb7,0xb3,0xe6,0xa4,0xbf,0xe8,0x9d,0xbd,0xe8,0x8e,0xbc,0xe9,0xb9,0x91,0x00};

//const unsigned char PY_mb_chuo  []={"戳绰踔啜龊辍"};
const unsigned char PY_mb_chuo  []={0xe6,0x88,0xb3,0xe7,0xbb,0xb0,0xe8,0xb8,0x94,0xe5,0x95,0x9c,0xe9,0xbe,0x8a,0xe8,0xbe,0x8d,0x00};

//const unsigned char PY_mb_ci    []={"次此词瓷慈雌磁辞刺茨伺疵赐差兹呲鹚祠糍"};
const unsigned char PY_mb_ci    []={0xe6,0xac,0xa1,0xe6,0xad,0xa4,0xe8,0xaf,0x8d,0xe7,0x93,0xb7,0xe6,0x85,0x88,0xe9,0x9b,0x8c,0xe7,0xa3,0x81,0xe8,0xbe,0x9e,0xe5,0x88,0xba,0xe8,0x8c,0xa8,0xe4,0xbc,0xba,0xe7,0x96,0xb5,0xe8,0xb5,0x90,0xe5,0xb7,0xae,0xe5,0x85,0xb9,0xe5,0x91,0xb2,0xe9,0xb9,0x9a,0xe7,0xa5,0xa0,0xe7,0xb3,0x8d,0x00};

//const unsigned char PY_mb_cong  []={"从丛葱匆聪囱琮枞淙璁骢苁"};
const unsigned char PY_mb_cong  []={0xe4,0xbb,0x8e,0xe4,0xb8,0x9b,0xe8,0x91,0xb1,0xe5,0x8c,0x86,0xe8,0x81,0xaa,0xe5,0x9b,0xb1,0xe7,0x90,0xae,0xe6,0x9e,0x9e,0xe6,0xb7,0x99,0xe7,0x92,0x81,0xe9,0xaa,0xa2,0xe8,0x8b,0x81,0x00};

//const unsigned char PY_mb_cou   []={"凑楱辏腠"};
const unsigned char PY_mb_cou   []={0xe5,0x87,0x91,0xe6,0xa5,0xb1,0xe8,0xbe,0x8f,0xe8,0x85,0xa0,0x00};

//const unsigned char PY_mb_cu    []={"粗醋簇促卒徂猝蔟蹙酢殂蹴"};
const unsigned char PY_mb_cu    []={0xe7,0xb2,0x97,0xe9,0x86,0x8b,0xe7,0xb0,0x87,0xe4,0xbf,0x83,0xe5,0x8d,0x92,0xe5,0xbe,0x82,0xe7,0x8c,0x9d,0xe8,0x94,0x9f,0xe8,0xb9,0x99,0xe9,0x85,0xa2,0xe6,0xae,0x82,0xe8,0xb9,0xb4,0x00};

//const unsigned char PY_mb_cuan  []={"窜蹿篡攒撺汆爨镩"};
const unsigned char PY_mb_cuan  []={0xe7,0xaa,0x9c,0xe8,0xb9,0xbf,0xe7,0xaf,0xa1,0xe6,0x94,0x92,0xe6,0x92,0xba,0xe6,0xb1,0x86,0xe7,0x88,0xa8,0xe9,0x95,0xa9,0x00};

//const unsigned char PY_mb_cui   []={"催脆摧翠崔淬衰瘁粹璀啐悴萃毳榱"};
const unsigned char PY_mb_cui   []={0xe5,0x82,0xac,0xe8,0x84,0x86,0xe6,0x91,0xa7,0xe7,0xbf,0xa0,0xe5,0xb4,0x94,0xe6,0xb7,0xac,0xe8,0xa1,0xb0,0xe7,0x98,0x81,0xe7,0xb2,0xb9,0xe7,0x92,0x80,0xe5,0x95,0x90,0xe6,0x82,0xb4,0xe8,0x90,0x83,0xe6,0xaf,0xb3,0xe6,0xa6,0xb1,0x00};

//const unsigned char PY_mb_cun   []={"村寸存蹲忖皴"};
const unsigned char PY_mb_cun   []={0xe6,0x9d,0x91,0xe5,0xaf,0xb8,0xe5,0xad,0x98,0xe8,0xb9,0xb2,0xe5,0xbf,0x96,0xe7,0x9a,0xb4,0x00};

//const unsigned char PY_mb_cuo   []={"错撮搓挫措磋嵯厝鹾脞痤蹉瘥锉矬"};
const unsigned char PY_mb_cuo   []={0xe9,0x94,0x99,0xe6,0x92,0xae,0xe6,0x90,0x93,0xe6,0x8c,0xab,0xe6,0x8e,0xaa,0xe7,0xa3,0x8b,0xe5,0xb5,0xaf,0xe5,0x8e,0x9d,0xe9,0xb9,0xbe,0xe8,0x84,0x9e,0xe7,0x97,0xa4,0xe8,0xb9,0x89,0xe7,0x98,0xa5,0xe9,0x94,0x89,0xe7,0x9f,0xac,0x00};

//const unsigned char PY_mb_da    []={"大答达打搭瘩塔笪耷哒褡疸怛靼妲沓嗒鞑"};
const unsigned char PY_mb_da    []={0xe5,0xa4,0xa7,0xe7,0xad,0x94,0xe8,0xbe,0xbe,0xe6,0x89,0x93,0xe6,0x90,0xad,0xe7,0x98,0xa9,0xe5,0xa1,0x94,0xe7,0xac,0xaa,0xe8,0x80,0xb7,0xe5,0x93,0x92,0xe8,0xa4,0xa1,0xe7,0x96,0xb8,0xe6,0x80,0x9b,0xe9,0x9d,0xbc,0xe5,0xa6,0xb2,0xe6,0xb2,0x93,0xe5,0x97,0x92,0xe9,0x9e,0x91,0x00};

//const unsigned char PY_mb_dai   []={"带代呆戴待袋逮歹贷怠傣大殆呔玳迨岱甙黛骀绐埭"};
const unsigned char PY_mb_dai   []={0xe5,0xb8,0xa6,0xe4,0xbb,0xa3,0xe5,0x91,0x86,0xe6,0x88,0xb4,0xe5,0xbe,0x85,0xe8,0xa2,0x8b,0xe9,0x80,0xae,0xe6,0xad,0xb9,0xe8,0xb4,0xb7,0xe6,0x80,0xa0,0xe5,0x82,0xa3,0xe5,0xa4,0xa7,0xe6,0xae,0x86,0xe5,0x91,0x94,0xe7,0x8e,0xb3,0xe8,0xbf,0xa8,0xe5,0xb2,0xb1,0xe7,0x94,0x99,0xe9,0xbb,0x9b,0xe9,0xaa,0x80,0xe7,0xbb,0x90,0xe5,0x9f,0xad,0x00};

//const unsigned char PY_mb_dan   []={"但单蛋担弹掸胆淡丹耽旦氮诞郸惮石疸澹瘅萏殚眈聃箪赕儋啖"};
const unsigned char PY_mb_dan   []={0xe4,0xbd,0x86,0xe5,0x8d,0x95,0xe8,0x9b,0x8b,0xe6,0x8b,0x85,0xe5,0xbc,0xb9,0xe6,0x8e,0xb8,0xe8,0x83,0x86,0xe6,0xb7,0xa1,0xe4,0xb8,0xb9,0xe8,0x80,0xbd,0xe6,0x97,0xa6,0xe6,0xb0,0xae,0xe8,0xaf,0x9e,0xe9,0x83,0xb8,0xe6,0x83,0xae,0xe7,0x9f,0xb3,0xe7,0x96,0xb8,0xe6,0xbe,0xb9,0xe7,0x98,0x85,0xe8,0x90,0x8f,0xe6,0xae,0x9a,0xe7,0x9c,0x88,0xe8,0x81,0x83,0xe7,0xae,0xaa,0xe8,0xb5,0x95,0xe5,0x84,0x8b,0xe5,0x95,0x96,0x00};

//const unsigned char PY_mb_dang  []={"当党挡档荡谠铛宕菪凼裆砀"};
const unsigned char PY_mb_dang  []={0xe5,0xbd,0x93,0xe5,0x85,0x9a,0xe6,0x8c,0xa1,0xe6,0xa1,0xa3,0xe8,0x8d,0xa1,0xe8,0xb0,0xa0,0xe9,0x93,0x9b,0xe5,0xae,0x95,0xe8,0x8f,0xaa,0xe5,0x87,0xbc,0xe8,0xa3,0x86,0xe7,0xa0,0x80,0x00};

//const unsigned char PY_mb_dao   []={"到道倒刀岛盗稻捣悼导蹈祷帱纛忉焘氘叨"};
const unsigned char PY_mb_dao   []={0xe5,0x88,0xb0,0xe9,0x81,0x93,0xe5,0x80,0x92,0xe5,0x88,0x80,0xe5,0xb2,0x9b,0xe7,0x9b,0x97,0xe7,0xa8,0xbb,0xe6,0x8d,0xa3,0xe6,0x82,0xbc,0xe5,0xaf,0xbc,0xe8,0xb9,0x88,0xe7,0xa5,0xb7,0xe5,0xb8,0xb1,0xe7,0xba,0x9b,0xe5,0xbf,0x89,0xe7,0x84,0x98,0xe6,0xb0,0x98,0xe5,0x8f,0xa8,0x00};

//const unsigned char PY_mb_de    []={"的地得德底锝"};
const unsigned char PY_mb_de    []={0xe7,0x9a,0x84,0xe5,0x9c,0xb0,0xe5,0xbe,0x97,0xe5,0xbe,0xb7,0xe5,0xba,0x95,0xe9,0x94,0x9d,0x00};

//const unsigned char PY_mb_deng  []={"等灯邓登澄瞪凳蹬磴镫噔嶝戥簦"};
const unsigned char PY_mb_deng  []={0xe7,0xad,0x89,0xe7,0x81,0xaf,0xe9,0x82,0x93,0xe7,0x99,0xbb,0xe6,0xbe,0x84,0xe7,0x9e,0xaa,0xe5,0x87,0xb3,0xe8,0xb9,0xac,0xe7,0xa3,0xb4,0xe9,0x95,0xab,0xe5,0x99,0x94,0xe5,0xb6,0x9d,0xe6,0x88,0xa5,0xe7,0xb0,0xa6,0x00};

//const unsigned char PY_mb_di    []={"地第底低敌抵滴帝递嫡弟缔堤的涤提笛迪狄翟蒂觌邸谛诋嘀柢骶羝氐棣睇娣荻碲镝坻籴砥"};
const unsigned char PY_mb_di    []={0xe5,0x9c,0xb0,0xe7,0xac,0xac,0xe5,0xba,0x95,0xe4,0xbd,0x8e,0xe6,0x95,0x8c,0xe6,0x8a,0xb5,0xe6,0xbb,0xb4,0xe5,0xb8,0x9d,0xe9,0x80,0x92,0xe5,0xab,0xa1,0xe5,0xbc,0x9f,0xe7,0xbc,0x94,0xe5,0xa0,0xa4,0xe7,0x9a,0x84,0xe6,0xb6,0xa4,0xe6,0x8f,0x90,0xe7,0xac,0x9b,0xe8,0xbf,0xaa,0xe7,0x8b,0x84,0xe7,0xbf,0x9f,0xe8,0x92,0x82,0xe8,0xa7,0x8c,0xe9,0x82,0xb8,0xe8,0xb0,0x9b,0xe8,0xaf,0x8b,0xe5,0x98,0x80,0xe6,0x9f,0xa2,0xe9,0xaa,0xb6,0xe7,0xbe,0x9d,0xe6,0xb0,0x90,0xe6,0xa3,0xa3,0xe7,0x9d,0x87,0xe5,0xa8,0xa3,0xe8,0x8d,0xbb,0xe7,0xa2,0xb2,0xe9,0x95,0x9d,0xe5,0x9d,0xbb,0xe7,0xb1,0xb4,0xe7,0xa0,0xa5,0x00};

//const unsigned char PY_mb_dia	[]={"嗲"};
const unsigned char PY_mb_dia	[]={0xe5,0x97,0xb2,0x00};

//const unsigned char PY_mb_dian  []={"点电店殿淀掂颠垫碘惦奠典佃靛滇甸踮钿坫阽癫簟玷巅癜"};
const unsigned char PY_mb_dian  []={0xe7,0x82,0xb9,0xe7,0x94,0xb5,0xe5,0xba,0x97,0xe6,0xae,0xbf,0xe6,0xb7,0x80,0xe6,0x8e,0x82,0xe9,0xa2,0xa0,0xe5,0x9e,0xab,0xe7,0xa2,0x98,0xe6,0x83,0xa6,0xe5,0xa5,0xa0,0xe5,0x85,0xb8,0xe4,0xbd,0x83,0xe9,0x9d,0x9b,0xe6,0xbb,0x87,0xe7,0x94,0xb8,0xe8,0xb8,0xae,0xe9,0x92,0xbf,0xe5,0x9d,0xab,0xe9,0x98,0xbd,0xe7,0x99,0xab,0xe7,0xb0,0x9f,0xe7,0x8e,0xb7,0xe5,0xb7,0x85,0xe7,0x99,0x9c,0x00};

//const unsigned char PY_mb_diao  []={"掉钓叼吊雕调刁碉凋鸟铞铫鲷貂"};
const unsigned char PY_mb_diao  []={0xe6,0x8e,0x89,0xe9,0x92,0x93,0xe5,0x8f,0xbc,0xe5,0x90,0x8a,0xe9,0x9b,0x95,0xe8,0xb0,0x83,0xe5,0x88,0x81,0xe7,0xa2,0x89,0xe5,0x87,0x8b,0xe9,0xb8,0x9f,0xe9,0x93,0x9e,0xe9,0x93,0xab,0xe9,0xb2,0xb7,0xe8,0xb2,0x82,0x00};

//const unsigned char PY_mb_die   []={"爹跌叠碟蝶迭谍牒堞瓞揲蹀耋鲽垤喋"};
const unsigned char PY_mb_die   []={0xe7,0x88,0xb9,0xe8,0xb7,0x8c,0xe5,0x8f,0xa0,0xe7,0xa2,0x9f,0xe8,0x9d,0xb6,0xe8,0xbf,0xad,0xe8,0xb0,0x8d,0xe7,0x89,0x92,0xe5,0xa0,0x9e,0xe7,0x93,0x9e,0xe6,0x8f,0xb2,0xe8,0xb9,0x80,0xe8,0x80,0x8b,0xe9,0xb2,0xbd,0xe5,0x9e,0xa4,0xe5,0x96,0x8b,0x00};

//const unsigned char PY_mb_ding  []={"顶定盯订叮丁钉鼎锭町玎铤腚碇疔仃耵酊啶"};
const unsigned char PY_mb_ding  []={0xe9,0xa1,0xb6,0xe5,0xae,0x9a,0xe7,0x9b,0xaf,0xe8,0xae,0xa2,0xe5,0x8f,0xae,0xe4,0xb8,0x81,0xe9,0x92,0x89,0xe9,0xbc,0x8e,0xe9,0x94,0xad,0xe7,0x94,0xba,0xe7,0x8e,0x8e,0xe9,0x93,0xa4,0xe8,0x85,0x9a,0xe7,0xa2,0x87,0xe7,0x96,0x94,0xe4,0xbb,0x83,0xe8,0x80,0xb5,0xe9,0x85,0x8a,0xe5,0x95,0xb6,0x00};

//const unsigned char PY_mb_diu   []={"丢铥"};
const unsigned char PY_mb_diu   []={0xe4,0xb8,0xa2,0xe9,0x93,0xa5,0x00};

//const unsigned char PY_mb_dong  []={"动东懂洞冻冬董栋侗恫峒鸫垌胨胴硐氡岽咚"};
const unsigned char PY_mb_dong  []={0xe5,0x8a,0xa8,0xe4,0xb8,0x9c,0xe6,0x87,0x82,0xe6,0xb4,0x9e,0xe5,0x86,0xbb,0xe5,0x86,0xac,0xe8,0x91,0xa3,0xe6,0xa0,0x8b,0xe4,0xbe,0x97,0xe6,0x81,0xab,0xe5,0xb3,0x92,0xe9,0xb8,0xab,0xe5,0x9e,0x8c,0xe8,0x83,0xa8,0xe8,0x83,0xb4,0xe7,0xa1,0x90,0xe6,0xb0,0xa1,0xe5,0xb2,0xbd,0xe5,0x92,0x9a,0x00};

//const unsigned char PY_mb_dou   []={"都斗豆逗陡抖痘兜读蚪窦篼蔸"};
const unsigned char PY_mb_dou   []={0xe9,0x83,0xbd,0xe6,0x96,0x97,0xe8,0xb1,0x86,0xe9,0x80,0x97,0xe9,0x99,0xa1,0xe6,0x8a,0x96,0xe7,0x97,0x98,0xe5,0x85,0x9c,0xe8,0xaf,0xbb,0xe8,0x9a,0xaa,0xe7,0xaa,0xa6,0xe7,0xaf,0xbc,0xe8,0x94,0xb8,0x00};

//const unsigned char PY_mb_du    []={"读度毒渡堵独肚镀赌睹杜督都犊妒顿蠹笃嘟渎椟牍黩髑芏"};
const unsigned char PY_mb_du    []={0xe8,0xaf,0xbb,0xe5,0xba,0xa6,0xe6,0xaf,0x92,0xe6,0xb8,0xa1,0xe5,0xa0,0xb5,0xe7,0x8b,0xac,0xe8,0x82,0x9a,0xe9,0x95,0x80,0xe8,0xb5,0x8c,0xe7,0x9d,0xb9,0xe6,0x9d,0x9c,0xe7,0x9d,0xa3,0xe9,0x83,0xbd,0xe7,0x8a,0x8a,0xe5,0xa6,0x92,0xe9,0xa1,0xbf,0xe8,0xa0,0xb9,0xe7,0xac,0x83,0xe5,0x98,0x9f,0xe6,0xb8,0x8e,0xe6,0xa4,0x9f,0xe7,0x89,0x8d,0xe9,0xbb,0xa9,0xe9,0xab,0x91,0xe8,0x8a,0x8f,0x00};

//const unsigned char PY_mb_duan  []={"段短断端锻缎椴煅簖"};
const unsigned char PY_mb_duan  []={0xe6,0xae,0xb5,0xe7,0x9f,0xad,0xe6,0x96,0xad,0xe7,0xab,0xaf,0xe9,0x94,0xbb,0xe7,0xbc,0x8e,0xe6,0xa4,0xb4,0xe7,0x85,0x85,0xe7,0xb0,0x96,0x00};

//const unsigned char PY_mb_dui   []={"对队堆兑敦镦碓怼憝"};
const unsigned char PY_mb_dui   []={0xe5,0xaf,0xb9,0xe9,0x98,0x9f,0xe5,0xa0,0x86,0xe5,0x85,0x91,0xe6,0x95,0xa6,0xe9,0x95,0xa6,0xe7,0xa2,0x93,0xe6,0x80,0xbc,0xe6,0x86,0x9d,0x00};

//const unsigned char PY_mb_dun   []={"吨顿蹲墩敦钝盾囤遁不趸沌盹镦礅炖砘"};
const unsigned char PY_mb_dun   []={0xe5,0x90,0xa8,0xe9,0xa1,0xbf,0xe8,0xb9,0xb2,0xe5,0xa2,0xa9,0xe6,0x95,0xa6,0xe9,0x92,0x9d,0xe7,0x9b,0xbe,0xe5,0x9b,0xa4,0xe9,0x81,0x81,0xe4,0xb8,0x8d,0xe8,0xb6,0xb8,0xe6,0xb2,0x8c,0xe7,0x9b,0xb9,0xe9,0x95,0xa6,0xe7,0xa4,0x85,0xe7,0x82,0x96,0xe7,0xa0,0x98,0x00};

//const unsigned char PY_mb_duo   []={"多朵夺舵剁垛跺惰堕掇哆驮度躲踱沲咄铎裰哚缍"};
const unsigned char PY_mb_duo   []={0xe5,0xa4,0x9a,0xe6,0x9c,0xb5,0xe5,0xa4,0xba,0xe8,0x88,0xb5,0xe5,0x89,0x81,0xe5,0x9e,0x9b,0xe8,0xb7,0xba,0xe6,0x83,0xb0,0xe5,0xa0,0x95,0xe6,0x8e,0x87,0xe5,0x93,0x86,0xe9,0xa9,0xae,0xe5,0xba,0xa6,0xe8,0xba,0xb2,0xe8,0xb8,0xb1,0xe6,0xb2,0xb2,0xe5,0x92,0x84,0xe9,0x93,0x8e,0xe8,0xa3,0xb0,0xe5,0x93,0x9a,0xe7,0xbc,0x8d,0x00};

//const unsigned char PY_mb_e     []={"饿哦额鹅蛾扼俄讹阿遏峨娥恶厄鄂锇谔垩锷阏萼苊轭婀莪鳄颚腭愕呃噩鹗屙"};
const unsigned char PY_mb_e     []={0xe9,0xa5,0xbf,0xe5,0x93,0xa6,0xe9,0xa2,0x9d,0xe9,0xb9,0x85,0xe8,0x9b,0xbe,0xe6,0x89,0xbc,0xe4,0xbf,0x84,0xe8,0xae,0xb9,0xe9,0x98,0xbf,0xe9,0x81,0x8f,0xe5,0xb3,0xa8,0xe5,0xa8,0xa5,0xe6,0x81,0xb6,0xe5,0x8e,0x84,0xe9,0x84,0x82,0xe9,0x94,0x87,0xe8,0xb0,0x94,0xe5,0x9e,0xa9,0xe9,0x94,0xb7,0xe9,0x98,0x8f,0xe8,0x90,0xbc,0xe8,0x8b,0x8a,0xe8,0xbd,0xad,0xe5,0xa9,0x80,0xe8,0x8e,0xaa,0xe9,0xb3,0x84,0xe9,0xa2,0x9a,0xe8,0x85,0xad,0xe6,0x84,0x95,0xe5,0x91,0x83,0xe5,0x99,0xa9,0xe9,0xb9,0x97,0xe5,0xb1,0x99,0x00};

//const unsigned char PY_mb_en    []={"恩摁嗯"};
const unsigned char PY_mb_en    []={0xe6,0x81,0xa9,0xe6,0x91,0x81,0xe5,0x97,0xaf,0x00};

//const unsigned char PY_mb_er    []={"而二耳儿饵尔贰洱珥鲕鸸佴迩铒"};
const unsigned char PY_mb_er    []={0xe8,0x80,0x8c,0xe4,0xba,0x8c,0xe8,0x80,0xb3,0xe5,0x84,0xbf,0xe9,0xa5,0xb5,0xe5,0xb0,0x94,0xe8,0xb4,0xb0,0xe6,0xb4,0xb1,0xe7,0x8f,0xa5,0xe9,0xb2,0x95,0xe9,0xb8,0xb8,0xe4,0xbd,0xb4,0xe8,0xbf,0xa9,0xe9,0x93,0x92,0x00};

//const unsigned char PY_mb_fa    []={"发法罚伐乏筏阀珐垡砝"};
const unsigned char PY_mb_fa    []={0xe5,0x8f,0x91,0xe6,0xb3,0x95,0xe7,0xbd,0x9a,0xe4,0xbc,0x90,0xe4,0xb9,0x8f,0xe7,0xad,0x8f,0xe9,0x98,0x80,0xe7,0x8f,0x90,0xe5,0x9e,0xa1,0xe7,0xa0,0x9d,0x00};

//const unsigned char PY_mb_fan   []={"反饭翻番犯凡帆返泛繁烦贩范樊藩矾钒燔蘩畈蕃蹯梵幡"};
const unsigned char PY_mb_fan   []={0xe5,0x8f,0x8d,0xe9,0xa5,0xad,0xe7,0xbf,0xbb,0xe7,0x95,0xaa,0xe7,0x8a,0xaf,0xe5,0x87,0xa1,0xe5,0xb8,0x86,0xe8,0xbf,0x94,0xe6,0xb3,0x9b,0xe7,0xb9,0x81,0xe7,0x83,0xa6,0xe8,0xb4,0xa9,0xe8,0x8c,0x83,0xe6,0xa8,0x8a,0xe8,0x97,0xa9,0xe7,0x9f,0xbe,0xe9,0x92,0x92,0xe7,0x87,0x94,0xe8,0x98,0xa9,0xe7,0x95,0x88,0xe8,0x95,0x83,0xe8,0xb9,0xaf,0xe6,0xa2,0xb5,0xe5,0xb9,0xa1,0x00};

//const unsigned char PY_mb_fang  []={"放房防纺芳方访仿坊妨肪钫彷邡枋舫鲂"};
const unsigned char PY_mb_fang  []={0xe6,0x94,0xbe,0xe6,0x88,0xbf,0xe9,0x98,0xb2,0xe7,0xba,0xba,0xe8,0x8a,0xb3,0xe6,0x96,0xb9,0xe8,0xae,0xbf,0xe4,0xbb,0xbf,0xe5,0x9d,0x8a,0xe5,0xa6,0xa8,0xe8,0x82,0xaa,0xe9,0x92,0xab,0xe5,0xbd,0xb7,0xe9,0x82,0xa1,0xe6,0x9e,0x8b,0xe8,0x88,0xab,0xe9,0xb2,0x82,0x00};

//const unsigned char PY_mb_fei   []={"非飞肥费肺废匪吠沸菲诽啡篚蜚腓扉妃斐狒芾悱镄霏翡榧淝鲱绯痱"};
const unsigned char PY_mb_fei   []={0xe9,0x9d,0x9e,0xe9,0xa3,0x9e,0xe8,0x82,0xa5,0xe8,0xb4,0xb9,0xe8,0x82,0xba,0xe5,0xba,0x9f,0xe5,0x8c,0xaa,0xe5,0x90,0xa0,0xe6,0xb2,0xb8,0xe8,0x8f,0xb2,0xe8,0xaf,0xbd,0xe5,0x95,0xa1,0xe7,0xaf,0x9a,0xe8,0x9c,0x9a,0xe8,0x85,0x93,0xe6,0x89,0x89,0xe5,0xa6,0x83,0xe6,0x96,0x90,0xe7,0x8b,0x92,0xe8,0x8a,0xbe,0xe6,0x82,0xb1,0xe9,0x95,0x84,0xe9,0x9c,0x8f,0xe7,0xbf,0xa1,0xe6,0xa6,0xa7,0xe6,0xb7,0x9d,0xe9,0xb2,0xb1,0xe7,0xbb,0xaf,0xe7,0x97,0xb1,0x00};

//const unsigned char PY_mb_fen   []={"分份芬粉坟奋愤纷忿粪酚焚吩氛汾棼瀵鲼玢偾鼢"};
const unsigned char PY_mb_fen   []={0xe5,0x88,0x86,0xe4,0xbb,0xbd,0xe8,0x8a,0xac,0xe7,0xb2,0x89,0xe5,0x9d,0x9f,0xe5,0xa5,0x8b,0xe6,0x84,0xa4,0xe7,0xba,0xb7,0xe5,0xbf,0xbf,0xe7,0xb2,0xaa,0xe9,0x85,0x9a,0xe7,0x84,0x9a,0xe5,0x90,0xa9,0xe6,0xb0,0x9b,0xe6,0xb1,0xbe,0xe6,0xa3,0xbc,0xe7,0x80,0xb5,0xe9,0xb2,0xbc,0xe7,0x8e,0xa2,0xe5,0x81,0xbe,0xe9,0xbc,0xa2,0x00};

//const unsigned char PY_mb_feng  []={"风封逢缝蜂丰枫疯冯奉讽凤峰锋烽砜俸酆葑沣唪"};
const unsigned char PY_mb_feng  []={0xe9,0xa3,0x8e,0xe5,0xb0,0x81,0xe9,0x80,0xa2,0xe7,0xbc,0x9d,0xe8,0x9c,0x82,0xe4,0xb8,0xb0,0xe6,0x9e,0xab,0xe7,0x96,0xaf,0xe5,0x86,0xaf,0xe5,0xa5,0x89,0xe8,0xae,0xbd,0xe5,0x87,0xa4,0xe5,0xb3,0xb0,0xe9,0x94,0x8b,0xe7,0x83,0xbd,0xe7,0xa0,0x9c,0xe4,0xbf,0xb8,0xe9,0x85,0x86,0xe8,0x91,0x91,0xe6,0xb2,0xa3,0xe5,0x94,0xaa,0x00};

//const unsigned char PY_mb_fo    []={"佛"};
const unsigned char PY_mb_fo    []={0xe4,0xbd,0x9b,0x00};

//const unsigned char PY_mb_fou   []={"否缶"};
const unsigned char PY_mb_fou   []={0xe5,0x90,0xa6,0xe7,0xbc,0xb6,0x00};

//const unsigned char PY_mb_fu    []={"副幅扶浮富福负伏付复服附俯斧赴缚拂夫父符孵敷赋辅府腐腹妇抚覆辐肤氟佛俘傅讣弗涪袱市甫釜脯腑阜咐黼砩苻趺跗蚨芾鲋幞茯滏蜉拊菔蝠鳆蝮绂绋赙罘稃匐麸凫桴莩孚馥驸怫祓呋郛芙艴"};
const unsigned char PY_mb_fu    []={0xe5,0x89,0xaf,0xe5,0xb9,0x85,0xe6,0x89,0xb6,0xe6,0xb5,0xae,0xe5,0xaf,0x8c,0xe7,0xa6,0x8f,0xe8,0xb4,0x9f,0xe4,0xbc,0x8f,0xe4,0xbb,0x98,0xe5,0xa4,0x8d,0xe6,0x9c,0x8d,0xe9,0x99,0x84,0xe4,0xbf,0xaf,0xe6,0x96,0xa7,0xe8,0xb5,0xb4,0xe7,0xbc,0x9a,0xe6,0x8b,0x82,0xe5,0xa4,0xab,0xe7,0x88,0xb6,0xe7,0xac,0xa6,0xe5,0xad,0xb5,0xe6,0x95,0xb7,0xe8,0xb5,0x8b,0xe8,0xbe,0x85,0xe5,0xba,0x9c,0xe8,0x85,0x90,0xe8,0x85,0xb9,0xe5,0xa6,0x87,0xe6,0x8a,0x9a,0xe8,0xa6,0x86,0xe8,0xbe,0x90,0xe8,0x82,0xa4,0xe6,0xb0,0x9f,0xe4,0xbd,0x9b,0xe4,0xbf,0x98,0xe5,0x82,0x85,0xe8,0xae,0xa3,0xe5,0xbc,0x97,0xe6,0xb6,0xaa,0xe8,0xa2,0xb1,0xe5,0xb8,0x82,0xe7,0x94,0xab,0xe9,0x87,0x9c,0xe8,0x84,0xaf,0xe8,0x85,0x91,0xe9,0x98,0x9c,0xe5,0x92,0x90,0xe9,0xbb,0xbc,0xe7,0xa0,0xa9,0xe8,0x8b,0xbb,0xe8,0xb6,0xba,0xe8,0xb7,0x97,0xe8,0x9a,0xa8,0xe8,0x8a,0xbe,0xe9,0xb2,0x8b,0xe5,0xb9,0x9e,0xe8,0x8c,0xaf,0xe6,0xbb,0x8f,0xe8,0x9c,0x89,0xe6,0x8b,0x8a,0xe8,0x8f,0x94,0xe8,0x9d,0xa0,0xe9,0xb3,0x86,0xe8,0x9d,0xae,0xe7,0xbb,0x82,0xe7,0xbb,0x8b,0xe8,0xb5,0x99,0xe7,0xbd,0x98,0xe7,0xa8,0x83,0xe5,0x8c,0x90,0xe9,0xba,0xb8,0xe5,0x87,0xab,0xe6,0xa1,0xb4,0xe8,0x8e,0xa9,0xe5,0xad,0x9a,0xe9,0xa6,0xa5,0xe9,0xa9,0xb8,0xe6,0x80,0xab,0xe7,0xa5,0x93,0xe5,0x91,0x8b,0xe9,0x83,0x9b,0xe8,0x8a,0x99,0xe8,0x89,0xb4,0x00};

//const unsigned char PY_mb_ga    []={"噶胳夹嘎咖轧钆伽旮尬尕尜呷"};
const unsigned char PY_mb_ga    []={0xe5,0x99,0xb6,0xe8,0x83,0xb3,0xe5,0xa4,0xb9,0xe5,0x98,0x8e,0xe5,0x92,0x96,0xe8,0xbd,0xa7,0xe9,0x92,0x86,0xe4,0xbc,0xbd,0xe6,0x97,0xae,0xe5,0xb0,0xac,0xe5,0xb0,0x95,0xe5,0xb0,0x9c,0xe5,0x91,0xb7,0x00};

//const unsigned char PY_mb_gai   []={"该改盖概钙芥溉戤垓丐陔赅"};
const unsigned char PY_mb_gai   []={0xe8,0xaf,0xa5,0xe6,0x94,0xb9,0xe7,0x9b,0x96,0xe6,0xa6,0x82,0xe9,0x92,0x99,0xe8,0x8a,0xa5,0xe6,0xba,0x89,0xe6,0x88,0xa4,0xe5,0x9e,0x93,0xe4,0xb8,0x90,0xe9,0x99,0x94,0xe8,0xb5,0x85,0x00};

//const unsigned char PY_mb_gan   []={"赶干感敢竿甘肝柑杆赣秆旰酐矸疳泔苷擀绀橄澉淦尴坩"};
const unsigned char PY_mb_gan   []={0xe8,0xb5,0xb6,0xe5,0xb9,0xb2,0xe6,0x84,0x9f,0xe6,0x95,0xa2,0xe7,0xab,0xbf,0xe7,0x94,0x98,0xe8,0x82,0x9d,0xe6,0x9f,0x91,0xe6,0x9d,0x86,0xe8,0xb5,0xa3,0xe7,0xa7,0x86,0xe6,0x97,0xb0,0xe9,0x85,0x90,0xe7,0x9f,0xb8,0xe7,0x96,0xb3,0xe6,0xb3,0x94,0xe8,0x8b,0xb7,0xe6,0x93,0x80,0xe7,0xbb,0x80,0xe6,0xa9,0x84,0xe6,0xbe,0x89,0xe6,0xb7,0xa6,0xe5,0xb0,0xb4,0xe5,0x9d,0xa9,0x00};

//const unsigned char PY_mb_gang  []={"刚钢纲港缸岗杠冈肛扛筻罡戆"};
const unsigned char PY_mb_gang  []={0xe5,0x88,0x9a,0xe9,0x92,0xa2,0xe7,0xba,0xb2,0xe6,0xb8,0xaf,0xe7,0xbc,0xb8,0xe5,0xb2,0x97,0xe6,0x9d,0xa0,0xe5,0x86,0x88,0xe8,0x82,0x9b,0xe6,0x89,0x9b,0xe7,0xad,0xbb,0xe7,0xbd,0xa1,0xe6,0x88,0x86,0x00};

//const unsigned char PY_mb_gao   []={"高搞告稿膏篙羔糕镐皋郜诰杲缟睾槔锆槁藁"};
const unsigned char PY_mb_gao   []={0xe9,0xab,0x98,0xe6,0x90,0x9e,0xe5,0x91,0x8a,0xe7,0xa8,0xbf,0xe8,0x86,0x8f,0xe7,0xaf,0x99,0xe7,0xbe,0x94,0xe7,0xb3,0x95,0xe9,0x95,0x90,0xe7,0x9a,0x8b,0xe9,0x83,0x9c,0xe8,0xaf,0xb0,0xe6,0x9d,0xb2,0xe7,0xbc,0x9f,0xe7,0x9d,0xbe,0xe6,0xa7,0x94,0xe9,0x94,0x86,0xe6,0xa7,0x81,0xe8,0x97,0x81,0x00};

//const unsigned char PY_mb_ge    []={"个各歌割哥搁格阁隔革咯胳葛蛤戈鸽疙盖屹合铬硌骼颌袼塥虼圪镉仡舸鬲嗝膈搿纥哿"};
const unsigned char PY_mb_ge    []={0xe4,0xb8,0xaa,0xe5,0x90,0x84,0xe6,0xad,0x8c,0xe5,0x89,0xb2,0xe5,0x93,0xa5,0xe6,0x90,0x81,0xe6,0xa0,0xbc,0xe9,0x98,0x81,0xe9,0x9a,0x94,0xe9,0x9d,0xa9,0xe5,0x92,0xaf,0xe8,0x83,0xb3,0xe8,0x91,0x9b,0xe8,0x9b,0xa4,0xe6,0x88,0x88,0xe9,0xb8,0xbd,0xe7,0x96,0x99,0xe7,0x9b,0x96,0xe5,0xb1,0xb9,0xe5,0x90,0x88,0xe9,0x93,0xac,0xe7,0xa1,0x8c,0xe9,0xaa,0xbc,0xe9,0xa2,0x8c,0xe8,0xa2,0xbc,0xe5,0xa1,0xa5,0xe8,0x99,0xbc,0xe5,0x9c,0xaa,0xe9,0x95,0x89,0xe4,0xbb,0xa1,0xe8,0x88,0xb8,0xe9,0xac,0xb2,0xe5,0x97,0x9d,0xe8,0x86,0x88,0xe6,0x90,0xbf,0xe7,0xba,0xa5,0xe5,0x93,0xbf,0x00};

//const unsigned char PY_mb_gei   []={"给"};
const unsigned char PY_mb_gei   []={0xe7,0xbb,0x99,0x00};

//const unsigned char PY_mb_gen   []={"跟根哏茛亘艮"};
const unsigned char PY_mb_gen   []={0xe8,0xb7,0x9f,0xe6,0xa0,0xb9,0xe5,0x93,0x8f,0xe8,0x8c,0x9b,0xe4,0xba,0x98,0xe8,0x89,0xae,0x00};

//const unsigned char PY_mb_geng  []={"更耕颈梗耿庚羹埂赓鲠哽绠"};
const unsigned char PY_mb_geng  []={0xe6,0x9b,0xb4,0xe8,0x80,0x95,0xe9,0xa2,0x88,0xe6,0xa2,0x97,0xe8,0x80,0xbf,0xe5,0xba,0x9a,0xe7,0xbe,0xb9,0xe5,0x9f,0x82,0xe8,0xb5,0x93,0xe9,0xb2,0xa0,0xe5,0x93,0xbd,0xe7,0xbb,0xa0,0x00};

//const unsigned char PY_mb_gong  []={"工公功共弓攻宫供恭拱贡躬巩汞龚红肱觥珙蚣"};
const unsigned char PY_mb_gong  []={0xe5,0xb7,0xa5,0xe5,0x85,0xac,0xe5,0x8a,0x9f,0xe5,0x85,0xb1,0xe5,0xbc,0x93,0xe6,0x94,0xbb,0xe5,0xae,0xab,0xe4,0xbe,0x9b,0xe6,0x81,0xad,0xe6,0x8b,0xb1,0xe8,0xb4,0xa1,0xe8,0xba,0xac,0xe5,0xb7,0xa9,0xe6,0xb1,0x9e,0xe9,0xbe,0x9a,0xe7,0xba,0xa2,0xe8,0x82,0xb1,0xe8,0xa7,0xa5,0xe7,0x8f,0x99,0xe8,0x9a,0xa3,0x00};

//const unsigned char PY_mb_gou   []={"够沟狗钩勾购构苟垢句岣彀枸鞲觏缑笱诟遘媾篝佝"};
const unsigned char PY_mb_gou   []={0xe5,0xa4,0x9f,0xe6,0xb2,0x9f,0xe7,0x8b,0x97,0xe9,0x92,0xa9,0xe5,0x8b,0xbe,0xe8,0xb4,0xad,0xe6,0x9e,0x84,0xe8,0x8b,0x9f,0xe5,0x9e,0xa2,0xe5,0x8f,0xa5,0xe5,0xb2,0xa3,0xe5,0xbd,0x80,0xe6,0x9e,0xb8,0xe9,0x9e,0xb2,0xe8,0xa7,0x8f,0xe7,0xbc,0x91,0xe7,0xac,0xb1,0xe8,0xaf,0x9f,0xe9,0x81,0x98,0xe5,0xaa,0xbe,0xe7,0xaf,0x9d,0xe4,0xbd,0x9d,0x00};

//const unsigned char PY_mb_gu    []={"古股鼓谷故孤箍姑顾固雇估咕骨辜沽蛊贾菇梏鸪汩轱崮菰鹄鹘钴臌酤呱鲴诂牯瞽毂锢牿痼觚蛄罟嘏"};
const unsigned char PY_mb_gu    []={0xe5,0x8f,0xa4,0xe8,0x82,0xa1,0xe9,0xbc,0x93,0xe8,0xb0,0xb7,0xe6,0x95,0x85,0xe5,0xad,0xa4,0xe7,0xae,0x8d,0xe5,0xa7,0x91,0xe9,0xa1,0xbe,0xe5,0x9b,0xba,0xe9,0x9b,0x87,0xe4,0xbc,0xb0,0xe5,0x92,0x95,0xe9,0xaa,0xa8,0xe8,0xbe,0x9c,0xe6,0xb2,0xbd,0xe8,0x9b,0x8a,0xe8,0xb4,0xbe,0xe8,0x8f,0x87,0xe6,0xa2,0x8f,0xe9,0xb8,0xaa,0xe6,0xb1,0xa9,0xe8,0xbd,0xb1,0xe5,0xb4,0xae,0xe8,0x8f,0xb0,0xe9,0xb9,0x84,0xe9,0xb9,0x98,0xe9,0x92,0xb4,0xe8,0x87,0x8c,0xe9,0x85,0xa4,0xe5,0x91,0xb1,0xe9,0xb2,0xb4,0xe8,0xaf,0x82,0xe7,0x89,0xaf,0xe7,0x9e,0xbd,0xe6,0xaf,0x82,0xe9,0x94,0xa2,0xe7,0x89,0xbf,0xe7,0x97,0xbc,0xe8,0xa7,0x9a,0xe8,0x9b,0x84,0xe7,0xbd,0x9f,0xe5,0x98,0x8f,0x00};

//const unsigned char PY_mb_gua   []={"挂刮瓜寡剐褂卦呱胍鸹栝诖"};
const unsigned char PY_mb_gua   []={0xe6,0x8c,0x82,0xe5,0x88,0xae,0xe7,0x93,0x9c,0xe5,0xaf,0xa1,0xe5,0x89,0x90,0xe8,0xa4,0x82,0xe5,0x8d,0xa6,0xe5,0x91,0xb1,0xe8,0x83,0x8d,0xe9,0xb8,0xb9,0xe6,0xa0,0x9d,0xe8,0xaf,0x96,0x00};

//const unsigned char PY_mb_guai  []={"怪拐乖掴"};
const unsigned char PY_mb_guai  []={0xe6,0x80,0xaa,0xe6,0x8b,0x90,0xe4,0xb9,0x96,0xe6,0x8e,0xb4,0x00};

//const unsigned char PY_mb_guan  []={"关管官观馆惯罐灌冠贯棺纶盥矜莞掼涫鳏鹳倌"};
const unsigned char PY_mb_guan  []={0xe5,0x85,0xb3,0xe7,0xae,0xa1,0xe5,0xae,0x98,0xe8,0xa7,0x82,0xe9,0xa6,0x86,0xe6,0x83,0xaf,0xe7,0xbd,0x90,0xe7,0x81,0x8c,0xe5,0x86,0xa0,0xe8,0xb4,0xaf,0xe6,0xa3,0xba,0xe7,0xba,0xb6,0xe7,0x9b,0xa5,0xe7,0x9f,0x9c,0xe8,0x8e,0x9e,0xe6,0x8e,0xbc,0xe6,0xb6,0xab,0xe9,0xb3,0x8f,0xe9,0xb9,0xb3,0xe5,0x80,0x8c,0x00};

//const unsigned char PY_mb_guang []={"光广逛桄犷咣胱"};
const unsigned char PY_mb_guang []={0xe5,0x85,0x89,0xe5,0xb9,0xbf,0xe9,0x80,0x9b,0xe6,0xa1,0x84,0xe7,0x8a,0xb7,0xe5,0x92,0xa3,0xe8,0x83,0xb1,0x00};

//const unsigned char PY_mb_gui   []={"归贵鬼跪轨规硅桂柜龟诡闺瑰圭刽傀癸炔庋宄桧刿鳜鲑皈匦妫晷簋炅"};
const unsigned char PY_mb_gui   []={0xe5,0xbd,0x92,0xe8,0xb4,0xb5,0xe9,0xac,0xbc,0xe8,0xb7,0xaa,0xe8,0xbd,0xa8,0xe8,0xa7,0x84,0xe7,0xa1,0x85,0xe6,0xa1,0x82,0xe6,0x9f,0x9c,0xe9,0xbe,0x9f,0xe8,0xaf,0xa1,0xe9,0x97,0xba,0xe7,0x91,0xb0,0xe5,0x9c,0xad,0xe5,0x88,0xbd,0xe5,0x82,0x80,0xe7,0x99,0xb8,0xe7,0x82,0x94,0xe5,0xba,0x8b,0xe5,0xae,0x84,0xe6,0xa1,0xa7,0xe5,0x88,0xbf,0xe9,0xb3,0x9c,0xe9,0xb2,0x91,0xe7,0x9a,0x88,0xe5,0x8c,0xa6,0xe5,0xa6,0xab,0xe6,0x99,0xb7,0xe7,0xb0,0x8b,0xe7,0x82,0x85,0x00};

//const unsigned char PY_mb_gun   []={"滚棍辊鲧衮磙绲"};
const unsigned char PY_mb_gun   []={0xe6,0xbb,0x9a,0xe6,0xa3,0x8d,0xe8,0xbe,0x8a,0xe9,0xb2,0xa7,0xe8,0xa1,0xae,0xe7,0xa3,0x99,0xe7,0xbb,0xb2,0x00};

//const unsigned char PY_mb_guo   []={"过国果裹锅郭涡埚椁聒馘猓崞掴帼呙虢蜾蝈"};
const unsigned char PY_mb_guo   []={0xe8,0xbf,0x87,0xe5,0x9b,0xbd,0xe6,0x9e,0x9c,0xe8,0xa3,0xb9,0xe9,0x94,0x85,0xe9,0x83,0xad,0xe6,0xb6,0xa1,0xe5,0x9f,0x9a,0xe6,0xa4,0x81,0xe8,0x81,0x92,0xe9,0xa6,0x98,0xe7,0x8c,0x93,0xe5,0xb4,0x9e,0xe6,0x8e,0xb4,0xe5,0xb8,0xbc,0xe5,0x91,0x99,0xe8,0x99,0xa2,0xe8,0x9c,0xbe,0xe8,0x9d,0x88,0x00};

//const unsigned char PY_mb_ha    []={"哈蛤虾铪"};
const unsigned char PY_mb_ha    []={0xe5,0x93,0x88,0xe8,0x9b,0xa4,0xe8,0x99,0xbe,0xe9,0x93,0xaa,0x00};

//const unsigned char PY_mb_hai   []={"还海害咳氦孩骇骸亥嗨醢胲"};
const unsigned char PY_mb_hai   []={0xe8,0xbf,0x98,0xe6,0xb5,0xb7,0xe5,0xae,0xb3,0xe5,0x92,0xb3,0xe6,0xb0,0xa6,0xe5,0xad,0xa9,0xe9,0xaa,0x87,0xe9,0xaa,0xb8,0xe4,0xba,0xa5,0xe5,0x97,0xa8,0xe9,0x86,0xa2,0xe8,0x83,0xb2,0x00};

//const unsigned char PY_mb_han   []={"喊含汗寒汉旱酣韩焊涵函憨翰罕撼捍憾悍邯邗菡撖瀚阚顸蚶焓颔晗鼾"};
const unsigned char PY_mb_han   []={0xe5,0x96,0x8a,0xe5,0x90,0xab,0xe6,0xb1,0x97,0xe5,0xaf,0x92,0xe6,0xb1,0x89,0xe6,0x97,0xb1,0xe9,0x85,0xa3,0xe9,0x9f,0xa9,0xe7,0x84,0x8a,0xe6,0xb6,0xb5,0xe5,0x87,0xbd,0xe6,0x86,0xa8,0xe7,0xbf,0xb0,0xe7,0xbd,0x95,0xe6,0x92,0xbc,0xe6,0x8d,0x8d,0xe6,0x86,0xbe,0xe6,0x82,0x8d,0xe9,0x82,0xaf,0xe9,0x82,0x97,0xe8,0x8f,0xa1,0xe6,0x92,0x96,0xe7,0x80,0x9a,0xe9,0x98,0x9a,0xe9,0xa1,0xb8,0xe8,0x9a,0xb6,0xe7,0x84,0x93,0xe9,0xa2,0x94,0xe6,0x99,0x97,0xe9,0xbc,0xbe,0x00};

//const unsigned char PY_mb_hang  []={"行巷航夯杭吭颃沆绗珩"};
const unsigned char PY_mb_hang  []={0xe8,0xa1,0x8c,0xe5,0xb7,0xb7,0xe8,0x88,0xaa,0xe5,0xa4,0xaf,0xe6,0x9d,0xad,0xe5,0x90,0xad,0xe9,0xa2,0x83,0xe6,0xb2,0x86,0xe7,0xbb,0x97,0xe7,0x8f,0xa9,0x00};

//const unsigned char PY_mb_hao   []={"好号浩嚎壕郝毫豪耗貉镐昊颢灏嚆蚝嗥皓蒿濠薅"};
const unsigned char PY_mb_hao   []={0xe5,0xa5,0xbd,0xe5,0x8f,0xb7,0xe6,0xb5,0xa9,0xe5,0x9a,0x8e,0xe5,0xa3,0x95,0xe9,0x83,0x9d,0xe6,0xaf,0xab,0xe8,0xb1,0xaa,0xe8,0x80,0x97,0xe8,0xb2,0x89,0xe9,0x95,0x90,0xe6,0x98,0x8a,0xe9,0xa2,0xa2,0xe7,0x81,0x8f,0xe5,0x9a,0x86,0xe8,0x9a,0x9d,0xe5,0x97,0xa5,0xe7,0x9a,0x93,0xe8,0x92,0xbf,0xe6,0xbf,0xa0,0xe8,0x96,0x85,0x00};

//const unsigned char PY_mb_he    []={"和喝合河禾核何呵荷贺赫褐盒鹤菏貉阂涸吓嗬劾盍翮阖颌壑诃纥曷"};
const unsigned char PY_mb_he    []={0xe5,0x92,0x8c,0xe5,0x96,0x9d,0xe5,0x90,0x88,0xe6,0xb2,0xb3,0xe7,0xa6,0xbe,0xe6,0xa0,0xb8,0xe4,0xbd,0x95,0xe5,0x91,0xb5,0xe8,0x8d,0xb7,0xe8,0xb4,0xba,0xe8,0xb5,0xab,0xe8,0xa4,0x90,0xe7,0x9b,0x92,0xe9,0xb9,0xa4,0xe8,0x8f,0x8f,0xe8,0xb2,0x89,0xe9,0x98,0x82,0xe6,0xb6,0xb8,0xe5,0x90,0x93,0xe5,0x97,0xac,0xe5,0x8a,0xbe,0xe7,0x9b,0x8d,0xe7,0xbf,0xae,0xe9,0x98,0x96,0xe9,0xa2,0x8c,0xe5,0xa3,0x91,0xe8,0xaf,0x83,0xe7,0xba,0xa5,0xe6,0x9b,0xb7,0x00};

//const unsigned char PY_mb_hei   []={"黑嘿"};
const unsigned char PY_mb_hei   []={0xe9,0xbb,0x91,0xe5,0x98,0xbf,0x00};

//const unsigned char PY_mb_hen   []={"很狠恨痕"};
const unsigned char PY_mb_hen   []={0xe5,0xbe,0x88,0xe7,0x8b,0xa0,0xe6,0x81,0xa8,0xe7,0x97,0x95,0x00};

//const unsigned char PY_mb_heng  []={"横恒哼衡亨行桁珩蘅"};
const unsigned char PY_mb_heng  []={0xe6,0xa8,0xaa,0xe6,0x81,0x92,0xe5,0x93,0xbc,0xe8,0xa1,0xa1,0xe4,0xba,0xa8,0xe8,0xa1,0x8c,0xe6,0xa1,0x81,0xe7,0x8f,0xa9,0xe8,0x98,0x85,0x00};

//const unsigned char PY_mb_hong  []={"红轰哄虹洪宏烘鸿弘讧訇蕻闳薨黉荭泓"};
const unsigned char PY_mb_hong  []={0xe7,0xba,0xa2,0xe8,0xbd,0xb0,0xe5,0x93,0x84,0xe8,0x99,0xb9,0xe6,0xb4,0xaa,0xe5,0xae,0x8f,0xe7,0x83,0x98,0xe9,0xb8,0xbf,0xe5,0xbc,0x98,0xe8,0xae,0xa7,0xe8,0xa8,0x87,0xe8,0x95,0xbb,0xe9,0x97,0xb3,0xe8,0x96,0xa8,0xe9,0xbb,0x89,0xe8,0x8d,0xad,0xe6,0xb3,0x93,0x00};

//const unsigned char PY_mb_hou   []={"后厚吼喉侯候猴鲎篌堠後逅糇骺瘊"};
const unsigned char PY_mb_hou   []={0xe5,0x90,0x8e,0xe5,0x8e,0x9a,0xe5,0x90,0xbc,0xe5,0x96,0x89,0xe4,0xbe,0xaf,0xe5,0x80,0x99,0xe7,0x8c,0xb4,0xe9,0xb2,0x8e,0xe7,0xaf,0x8c,0xe5,0xa0,0xa0,0xe5,0xbe,0x8c,0xe9,0x80,0x85,0xe7,0xb3,0x87,0xe9,0xaa,0xba,0xe7,0x98,0x8a,0x00};

//const unsigned char PY_mb_hu    []={"湖户呼虎壶互胡护糊弧忽狐蝴葫沪乎戏核和瑚唬鹕冱怙鹱笏戽扈鹘浒祜醐琥囫烀轷瓠煳斛鹄猢惚岵滹觳唿槲"};
const unsigned char PY_mb_hu    []={0xe6,0xb9,0x96,0xe6,0x88,0xb7,0xe5,0x91,0xbc,0xe8,0x99,0x8e,0xe5,0xa3,0xb6,0xe4,0xba,0x92,0xe8,0x83,0xa1,0xe6,0x8a,0xa4,0xe7,0xb3,0x8a,0xe5,0xbc,0xa7,0xe5,0xbf,0xbd,0xe7,0x8b,0x90,0xe8,0x9d,0xb4,0xe8,0x91,0xab,0xe6,0xb2,0xaa,0xe4,0xb9,0x8e,0xe6,0x88,0x8f,0xe6,0xa0,0xb8,0xe5,0x92,0x8c,0xe7,0x91,0x9a,0xe5,0x94,0xac,0xe9,0xb9,0x95,0xe5,0x86,0xb1,0xe6,0x80,0x99,0xe9,0xb9,0xb1,0xe7,0xac,0x8f,0xe6,0x88,0xbd,0xe6,0x89,0x88,0xe9,0xb9,0x98,0xe6,0xb5,0x92,0xe7,0xa5,0x9c,0xe9,0x86,0x90,0xe7,0x90,0xa5,0xe5,0x9b,0xab,0xe7,0x83,0x80,0xe8,0xbd,0xb7,0xe7,0x93,0xa0,0xe7,0x85,0xb3,0xe6,0x96,0x9b,0xe9,0xb9,0x84,0xe7,0x8c,0xa2,0xe6,0x83,0x9a,0xe5,0xb2,0xb5,0xe6,0xbb,0xb9,0xe8,0xa7,0xb3,0xe5,0x94,0xbf,0xe6,0xa7,0xb2,0x00};

//const unsigned char PY_mb_hua   []={"话花化画华划滑哗猾豁铧桦骅砉"};
const unsigned char PY_mb_hua   []={0xe8,0xaf,0x9d,0xe8,0x8a,0xb1,0xe5,0x8c,0x96,0xe7,0x94,0xbb,0xe5,0x8d,0x8e,0xe5,0x88,0x92,0xe6,0xbb,0x91,0xe5,0x93,0x97,0xe7,0x8c,0xbe,0xe8,0xb1,0x81,0xe9,0x93,0xa7,0xe6,0xa1,0xa6,0xe9,0xaa,0x85,0xe7,0xa0,0x89,0x00};

//const unsigned char PY_mb_huai  []={"坏怀淮槐徊划踝"};
const unsigned char PY_mb_huai  []={0xe5,0x9d,0x8f,0xe6,0x80,0x80,0xe6,0xb7,0xae,0xe6,0xa7,0x90,0xe5,0xbe,0x8a,0xe5,0x88,0x92,0xe8,0xb8,0x9d,0x00};

//const unsigned char PY_mb_huan  []={"换还唤环患缓欢幻宦涣焕豢桓痪漶獾擐逭鲩郇鬟寰奂锾圜洹萑缳浣"};
const unsigned char PY_mb_huan  []={0xe6,0x8d,0xa2,0xe8,0xbf,0x98,0xe5,0x94,0xa4,0xe7,0x8e,0xaf,0xe6,0x82,0xa3,0xe7,0xbc,0x93,0xe6,0xac,0xa2,0xe5,0xb9,0xbb,0xe5,0xae,0xa6,0xe6,0xb6,0xa3,0xe7,0x84,0x95,0xe8,0xb1,0xa2,0xe6,0xa1,0x93,0xe7,0x97,0xaa,0xe6,0xbc,0xb6,0xe7,0x8d,0xbe,0xe6,0x93,0x90,0xe9,0x80,0xad,0xe9,0xb2,0xa9,0xe9,0x83,0x87,0xe9,0xac,0x9f,0xe5,0xaf,0xb0,0xe5,0xa5,0x82,0xe9,0x94,0xbe,0xe5,0x9c,0x9c,0xe6,0xb4,0xb9,0xe8,0x90,0x91,0xe7,0xbc,0xb3,0xe6,0xb5,0xa3,0x00};

//const unsigned char PY_mb_huang []={"黄慌晃荒簧凰皇谎惶蝗磺恍煌幌隍肓潢篁徨鳇"};
const unsigned char PY_mb_huang []={0xe9,0xbb,0x84,0xe6,0x85,0x8c,0xe6,0x99,0x83,0xe8,0x8d,0x92,0xe7,0xb0,0xa7,0xe5,0x87,0xb0,0xe7,0x9a,0x87,0xe8,0xb0,0x8e,0xe6,0x83,0xb6,0xe8,0x9d,0x97,0xe7,0xa3,0xba,0xe6,0x81,0x8d,0xe7,0x85,0x8c,0xe5,0xb9,0x8c,0xe9,0x9a,0x8d,0xe8,0x82,0x93,0xe6,0xbd,0xa2,0xe7,0xaf,0x81,0xe5,0xbe,0xa8,0xe9,0xb3,0x87,0x00};

//const unsigned char PY_mb_hui   []={"回会灰绘挥汇辉毁悔惠晦徽恢秽慧贿蛔讳徊卉烩诲彗浍珲蕙喙恚哕晖隳麾诙蟪茴洄咴虺荟缋"};
const unsigned char PY_mb_hui   []={0xe5,0x9b,0x9e,0xe4,0xbc,0x9a,0xe7,0x81,0xb0,0xe7,0xbb,0x98,0xe6,0x8c,0xa5,0xe6,0xb1,0x87,0xe8,0xbe,0x89,0xe6,0xaf,0x81,0xe6,0x82,0x94,0xe6,0x83,0xa0,0xe6,0x99,0xa6,0xe5,0xbe,0xbd,0xe6,0x81,0xa2,0xe7,0xa7,0xbd,0xe6,0x85,0xa7,0xe8,0xb4,0xbf,0xe8,0x9b,0x94,0xe8,0xae,0xb3,0xe5,0xbe,0x8a,0xe5,0x8d,0x89,0xe7,0x83,0xa9,0xe8,0xaf,0xb2,0xe5,0xbd,0x97,0xe6,0xb5,0x8d,0xe7,0x8f,0xb2,0xe8,0x95,0x99,0xe5,0x96,0x99,0xe6,0x81,0x9a,0xe5,0x93,0x95,0xe6,0x99,0x96,0xe9,0x9a,0xb3,0xe9,0xba,0xbe,0xe8,0xaf,0x99,0xe8,0x9f,0xaa,0xe8,0x8c,0xb4,0xe6,0xb4,0x84,0xe5,0x92,0xb4,0xe8,0x99,0xba,0xe8,0x8d,0x9f,0xe7,0xbc,0x8b,0x00};

//const unsigned char PY_mb_hun   []={"混昏荤浑婚魂阍珲馄溷诨"};
const unsigned char PY_mb_hun   []={0xe6,0xb7,0xb7,0xe6,0x98,0x8f,0xe8,0x8d,0xa4,0xe6,0xb5,0x91,0xe5,0xa9,0x9a,0xe9,0xad,0x82,0xe9,0x98,0x8d,0xe7,0x8f,0xb2,0xe9,0xa6,0x84,0xe6,0xba,0xb7,0xe8,0xaf,0xa8,0x00};

//const unsigned char PY_mb_huo   []={"或活火伙货和获祸豁霍惑嚯镬耠劐藿攉锪蠖钬夥"};
const unsigned char PY_mb_huo   []={0xe6,0x88,0x96,0xe6,0xb4,0xbb,0xe7,0x81,0xab,0xe4,0xbc,0x99,0xe8,0xb4,0xa7,0xe5,0x92,0x8c,0xe8,0x8e,0xb7,0xe7,0xa5,0xb8,0xe8,0xb1,0x81,0xe9,0x9c,0x8d,0xe6,0x83,0x91,0xe5,0x9a,0xaf,0xe9,0x95,0xac,0xe8,0x80,0xa0,0xe5,0x8a,0x90,0xe8,0x97,0xbf,0xe6,0x94,0x89,0xe9,0x94,0xaa,0xe8,0xa0,0x96,0xe9,0x92,0xac,0xe5,0xa4,0xa5,0x00};

//const unsigned char PY_mb_ji    []={"几及急既即机鸡积记级极计挤己季寄纪系基激吉脊际击圾畸箕肌饥迹讥姬绩棘辑籍缉集疾汲嫉蓟技冀伎祭剂悸济寂期其奇忌齐妓继给革稽墼洎鲚屐齑戟鲫嵇矶稷戢虮诘笈暨笄剞叽蒺跻嵴掎跽霁唧畿荠瘠玑羁丌偈芨佶赍楫髻咭蕺觊麂"};
const unsigned char PY_mb_ji    []={0xe5,0x87,0xa0,0xe5,0x8f,0x8a,0xe6,0x80,0xa5,0xe6,0x97,0xa2,0xe5,0x8d,0xb3,0xe6,0x9c,0xba,0xe9,0xb8,0xa1,0xe7,0xa7,0xaf,0xe8,0xae,0xb0,0xe7,0xba,0xa7,0xe6,0x9e,0x81,0xe8,0xae,0xa1,0xe6,0x8c,0xa4,0xe5,0xb7,0xb1,0xe5,0xad,0xa3,0xe5,0xaf,0x84,0xe7,0xba,0xaa,0xe7,0xb3,0xbb,0xe5,0x9f,0xba,0xe6,0xbf,0x80,0xe5,0x90,0x89,0xe8,0x84,0x8a,0xe9,0x99,0x85,0xe5,0x87,0xbb,0xe5,0x9c,0xbe,0xe7,0x95,0xb8,0xe7,0xae,0x95,0xe8,0x82,0x8c,0xe9,0xa5,0xa5,0xe8,0xbf,0xb9,0xe8,0xae,0xa5,0xe5,0xa7,0xac,0xe7,0xbb,0xa9,0xe6,0xa3,0x98,0xe8,0xbe,0x91,0xe7,0xb1,0x8d,0xe7,0xbc,0x89,0xe9,0x9b,0x86,0xe7,0x96,0xbe,0xe6,0xb1,0xb2,0xe5,0xab,0x89,0xe8,0x93,0x9f,0xe6,0x8a,0x80,0xe5,0x86,0x80,0xe4,0xbc,0x8e,0xe7,0xa5,0xad,0xe5,0x89,0x82,0xe6,0x82,0xb8,0xe6,0xb5,0x8e,0xe5,0xaf,0x82,0xe6,0x9c,0x9f,0xe5,0x85,0xb6,0xe5,0xa5,0x87,0xe5,0xbf,0x8c,0xe9,0xbd,0x90,0xe5,0xa6,0x93,0xe7,0xbb,0xa7,0xe7,0xbb,0x99,0xe9,0x9d,0xa9,0xe7,0xa8,0xbd,0xe5,0xa2,0xbc,0xe6,0xb4,0x8e,0xe9,0xb2,0x9a,0xe5,0xb1,0x90,0xe9,0xbd,0x91,0xe6,0x88,0x9f,0xe9,0xb2,0xab,0xe5,0xb5,0x87,0xe7,0x9f,0xb6,0xe7,0xa8,0xb7,0xe6,0x88,0xa2,0xe8,0x99,0xae,0xe8,0xaf,0x98,0xe7,0xac,0x88,0xe6,0x9a,0xa8,0xe7,0xac,0x84,0xe5,0x89,0x9e,0xe5,0x8f,0xbd,0xe8,0x92,0xba,0xe8,0xb7,0xbb,0xe5,0xb5,0xb4,0xe6,0x8e,0x8e,0xe8,0xb7,0xbd,0xe9,0x9c,0x81,0xe5,0x94,0xa7,0xe7,0x95,0xbf,0xe8,0x8d,0xa0,0xe7,0x98,0xa0,0xe7,0x8e,0x91,0xe7,0xbe,0x81,0xe4,0xb8,0x8c,0xe5,0x81,0x88,0xe8,0x8a,0xa8,0xe4,0xbd,0xb6,0xe8,0xb5,0x8d,0xe6,0xa5,0xab,0xe9,0xab,0xbb,0xe5,0x92,0xad,0xe8,0x95,0xba,0xe8,0xa7,0x8a,0xe9,0xba,0x82,0x00};

//const unsigned char PY_mb_jia   []={"家加假价架甲佳夹嘉驾嫁枷荚颊钾稼茄贾铗葭迦戛浃镓痂恝岬跏嘏伽胛笳珈瘕郏袈蛱"};
const unsigned char PY_mb_jia   []={0xe5,0xae,0xb6,0xe5,0x8a,0xa0,0xe5,0x81,0x87,0xe4,0xbb,0xb7,0xe6,0x9e,0xb6,0xe7,0x94,0xb2,0xe4,0xbd,0xb3,0xe5,0xa4,0xb9,0xe5,0x98,0x89,0xe9,0xa9,0xbe,0xe5,0xab,0x81,0xe6,0x9e,0xb7,0xe8,0x8d,0x9a,0xe9,0xa2,0x8a,0xe9,0x92,0xbe,0xe7,0xa8,0xbc,0xe8,0x8c,0x84,0xe8,0xb4,0xbe,0xe9,0x93,0x97,0xe8,0x91,0xad,0xe8,0xbf,0xa6,0xe6,0x88,0x9b,0xe6,0xb5,0x83,0xe9,0x95,0x93,0xe7,0x97,0x82,0xe6,0x81,0x9d,0xe5,0xb2,0xac,0xe8,0xb7,0x8f,0xe5,0x98,0x8f,0xe4,0xbc,0xbd,0xe8,0x83,0x9b,0xe7,0xac,0xb3,0xe7,0x8f,0x88,0xe7,0x98,0x95,0xe9,0x83,0x8f,0xe8,0xa2,0x88,0xe8,0x9b,0xb1,0x00};

//const unsigned char PY_mb_jian  []={"见件减尖间键贱肩兼建检箭煎简剪歼监坚奸健艰荐剑渐溅涧鉴浅践捡柬笺俭碱硷拣舰槛缄茧饯翦鞯戋谏牮枧腱趼缣搛戬毽菅鲣笕谫楗囝蹇裥踺睑謇鹣蒹僭锏湔"};
const unsigned char PY_mb_jian  []={0xe8,0xa7,0x81,0xe4,0xbb,0xb6,0xe5,0x87,0x8f,0xe5,0xb0,0x96,0xe9,0x97,0xb4,0xe9,0x94,0xae,0xe8,0xb4,0xb1,0xe8,0x82,0xa9,0xe5,0x85,0xbc,0xe5,0xbb,0xba,0xe6,0xa3,0x80,0xe7,0xae,0xad,0xe7,0x85,0x8e,0xe7,0xae,0x80,0xe5,0x89,0xaa,0xe6,0xad,0xbc,0xe7,0x9b,0x91,0xe5,0x9d,0x9a,0xe5,0xa5,0xb8,0xe5,0x81,0xa5,0xe8,0x89,0xb0,0xe8,0x8d,0x90,0xe5,0x89,0x91,0xe6,0xb8,0x90,0xe6,0xba,0x85,0xe6,0xb6,0xa7,0xe9,0x89,0xb4,0xe6,0xb5,0x85,0xe8,0xb7,0xb5,0xe6,0x8d,0xa1,0xe6,0x9f,0xac,0xe7,0xac,0xba,0xe4,0xbf,0xad,0xe7,0xa2,0xb1,0xe7,0xa1,0xb7,0xe6,0x8b,0xa3,0xe8,0x88,0xb0,0xe6,0xa7,0x9b,0xe7,0xbc,0x84,0xe8,0x8c,0xa7,0xe9,0xa5,0xaf,0xe7,0xbf,0xa6,0xe9,0x9e,0xaf,0xe6,0x88,0x8b,0xe8,0xb0,0x8f,0xe7,0x89,0xae,0xe6,0x9e,0xa7,0xe8,0x85,0xb1,0xe8,0xb6,0xbc,0xe7,0xbc,0xa3,0xe6,0x90,0x9b,0xe6,0x88,0xac,0xe6,0xaf,0xbd,0xe8,0x8f,0x85,0xe9,0xb2,0xa3,0xe7,0xac,0x95,0xe8,0xb0,0xab,0xe6,0xa5,0x97,0xe5,0x9b,0x9d,0xe8,0xb9,0x87,0xe8,0xa3,0xa5,0xe8,0xb8,0xba,0xe7,0x9d,0x91,0xe8,0xac,0x87,0xe9,0xb9,0xa3,0xe8,0x92,0xb9,0xe5,0x83,0xad,0xe9,0x94,0x8f,0xe6,0xb9,0x94,0x00};

//const unsigned char PY_mb_jiang []={"将讲江奖降浆僵姜酱蒋疆匠强桨虹豇礓缰犟耩绛茳糨洚"};
const unsigned char PY_mb_jiang []={0xe5,0xb0,0x86,0xe8,0xae,0xb2,0xe6,0xb1,0x9f,0xe5,0xa5,0x96,0xe9,0x99,0x8d,0xe6,0xb5,0x86,0xe5,0x83,0xb5,0xe5,0xa7,0x9c,0xe9,0x85,0xb1,0xe8,0x92,0x8b,0xe7,0x96,0x86,0xe5,0x8c,0xa0,0xe5,0xbc,0xba,0xe6,0xa1,0xa8,0xe8,0x99,0xb9,0xe8,0xb1,0x87,0xe7,0xa4,0x93,0xe7,0xbc,0xb0,0xe7,0x8a,0x9f,0xe8,0x80,0xa9,0xe7,0xbb,0x9b,0xe8,0x8c,0xb3,0xe7,0xb3,0xa8,0xe6,0xb4,0x9a,0x00};

//const unsigned char PY_mb_jiao  []={"叫脚交角教较缴觉焦胶娇绞校搅骄狡浇矫郊嚼蕉轿窖椒礁饺铰酵侥剿徼艽僬蛟敫峤跤姣皎茭鹪噍醮佼湫鲛挢"};
const unsigned char PY_mb_jiao  []={0xe5,0x8f,0xab,0xe8,0x84,0x9a,0xe4,0xba,0xa4,0xe8,0xa7,0x92,0xe6,0x95,0x99,0xe8,0xbe,0x83,0xe7,0xbc,0xb4,0xe8,0xa7,0x89,0xe7,0x84,0xa6,0xe8,0x83,0xb6,0xe5,0xa8,0x87,0xe7,0xbb,0x9e,0xe6,0xa0,0xa1,0xe6,0x90,0x85,0xe9,0xaa,0x84,0xe7,0x8b,0xa1,0xe6,0xb5,0x87,0xe7,0x9f,0xab,0xe9,0x83,0x8a,0xe5,0x9a,0xbc,0xe8,0x95,0x89,0xe8,0xbd,0xbf,0xe7,0xaa,0x96,0xe6,0xa4,0x92,0xe7,0xa4,0x81,0xe9,0xa5,0xba,0xe9,0x93,0xb0,0xe9,0x85,0xb5,0xe4,0xbe,0xa5,0xe5,0x89,0xbf,0xe5,0xbe,0xbc,0xe8,0x89,0xbd,0xe5,0x83,0xac,0xe8,0x9b,0x9f,0xe6,0x95,0xab,0xe5,0xb3,0xa4,0xe8,0xb7,0xa4,0xe5,0xa7,0xa3,0xe7,0x9a,0x8e,0xe8,0x8c,0xad,0xe9,0xb9,0xaa,0xe5,0x99,0x8d,0xe9,0x86,0xae,0xe4,0xbd,0xbc,0xe6,0xb9,0xab,0xe9,0xb2,0x9b,0xe6,0x8c,0xa2,0x00};

//const unsigned char PY_mb_jie   []={"接节街借皆截解界结届姐揭戒介阶劫芥竭洁疥藉价楷秸桔杰捷诫睫家偈桀喈拮骱羯蚧嗟颉鲒婕碣讦孑疖诘"};
const unsigned char PY_mb_jie   []={0xe6,0x8e,0xa5,0xe8,0x8a,0x82,0xe8,0xa1,0x97,0xe5,0x80,0x9f,0xe7,0x9a,0x86,0xe6,0x88,0xaa,0xe8,0xa7,0xa3,0xe7,0x95,0x8c,0xe7,0xbb,0x93,0xe5,0xb1,0x8a,0xe5,0xa7,0x90,0xe6,0x8f,0xad,0xe6,0x88,0x92,0xe4,0xbb,0x8b,0xe9,0x98,0xb6,0xe5,0x8a,0xab,0xe8,0x8a,0xa5,0xe7,0xab,0xad,0xe6,0xb4,0x81,0xe7,0x96,0xa5,0xe8,0x97,0x89,0xe4,0xbb,0xb7,0xe6,0xa5,0xb7,0xe7,0xa7,0xb8,0xe6,0xa1,0x94,0xe6,0x9d,0xb0,0xe6,0x8d,0xb7,0xe8,0xaf,0xab,0xe7,0x9d,0xab,0xe5,0xae,0xb6,0xe5,0x81,0x88,0xe6,0xa1,0x80,0xe5,0x96,0x88,0xe6,0x8b,0xae,0xe9,0xaa,0xb1,0xe7,0xbe,0xaf,0xe8,0x9a,0xa7,0xe5,0x97,0x9f,0xe9,0xa2,0x89,0xe9,0xb2,0x92,0xe5,0xa9,0x95,0xe7,0xa2,0xa3,0xe8,0xae,0xa6,0xe5,0xad,0x91,0xe7,0x96,0x96,0xe8,0xaf,0x98,0x00};

//const unsigned char PY_mb_jin   []={"进近今仅紧金斤尽劲禁浸锦晋筋津谨巾襟烬靳廑瑾馑槿衿堇荩矜噤缙卺妗赆觐"};
const unsigned char PY_mb_jin   []={0xe8,0xbf,0x9b,0xe8,0xbf,0x91,0xe4,0xbb,0x8a,0xe4,0xbb,0x85,0xe7,0xb4,0xa7,0xe9,0x87,0x91,0xe6,0x96,0xa4,0xe5,0xb0,0xbd,0xe5,0x8a,0xb2,0xe7,0xa6,0x81,0xe6,0xb5,0xb8,0xe9,0x94,0xa6,0xe6,0x99,0x8b,0xe7,0xad,0x8b,0xe6,0xb4,0xa5,0xe8,0xb0,0xa8,0xe5,0xb7,0xbe,0xe8,0xa5,0x9f,0xe7,0x83,0xac,0xe9,0x9d,0xb3,0xe5,0xbb,0x91,0xe7,0x91,0xbe,0xe9,0xa6,0x91,0xe6,0xa7,0xbf,0xe8,0xa1,0xbf,0xe5,0xa0,0x87,0xe8,0x8d,0xa9,0xe7,0x9f,0x9c,0xe5,0x99,0xa4,0xe7,0xbc,0x99,0xe5,0x8d,0xba,0xe5,0xa6,0x97,0xe8,0xb5,0x86,0xe8,0xa7,0x90,0x00};

//const unsigned char PY_mb_jing  []={"竟静井惊经镜京净敬精景警竞境径荆晶鲸粳颈兢茎睛劲痉靖肼獍阱腈弪刭憬婧胫菁儆旌迳靓泾"};
const unsigned char PY_mb_jing  []={0xe7,0xab,0x9f,0xe9,0x9d,0x99,0xe4,0xba,0x95,0xe6,0x83,0x8a,0xe7,0xbb,0x8f,0xe9,0x95,0x9c,0xe4,0xba,0xac,0xe5,0x87,0x80,0xe6,0x95,0xac,0xe7,0xb2,0xbe,0xe6,0x99,0xaf,0xe8,0xad,0xa6,0xe7,0xab,0x9e,0xe5,0xa2,0x83,0xe5,0xbe,0x84,0xe8,0x8d,0x86,0xe6,0x99,0xb6,0xe9,0xb2,0xb8,0xe7,0xb2,0xb3,0xe9,0xa2,0x88,0xe5,0x85,0xa2,0xe8,0x8c,0x8e,0xe7,0x9d,0x9b,0xe5,0x8a,0xb2,0xe7,0x97,0x89,0xe9,0x9d,0x96,0xe8,0x82,0xbc,0xe7,0x8d,0x8d,0xe9,0x98,0xb1,0xe8,0x85,0x88,0xe5,0xbc,0xaa,0xe5,0x88,0xad,0xe6,0x86,0xac,0xe5,0xa9,0xa7,0xe8,0x83,0xab,0xe8,0x8f,0x81,0xe5,0x84,0x86,0xe6,0x97,0x8c,0xe8,0xbf,0xb3,0xe9,0x9d,0x93,0xe6,0xb3,0xbe,0x00};

//const unsigned char PY_mb_jiong []={"窘炯扃迥"};
const unsigned char PY_mb_jiong []={0xe7,0xaa,0x98,0xe7,0x82,0xaf,0xe6,0x89,0x83,0xe8,0xbf,0xa5,0x00};

//const unsigned char PY_mb_jiu   []={"就九酒旧久揪救纠舅究韭厩臼玖灸咎疚赳鹫蹴僦柩桕鬏鸠阄啾"};
const unsigned char PY_mb_jiu   []={0xe5,0xb0,0xb1,0xe4,0xb9,0x9d,0xe9,0x85,0x92,0xe6,0x97,0xa7,0xe4,0xb9,0x85,0xe6,0x8f,0xaa,0xe6,0x95,0x91,0xe7,0xba,0xa0,0xe8,0x88,0x85,0xe7,0xa9,0xb6,0xe9,0x9f,0xad,0xe5,0x8e,0xa9,0xe8,0x87,0xbc,0xe7,0x8e,0x96,0xe7,0x81,0xb8,0xe5,0x92,0x8e,0xe7,0x96,0x9a,0xe8,0xb5,0xb3,0xe9,0xb9,0xab,0xe8,0xb9,0xb4,0xe5,0x83,0xa6,0xe6,0x9f,0xa9,0xe6,0xa1,0x95,0xe9,0xac,0x8f,0xe9,0xb8,0xa0,0xe9,0x98,0x84,0xe5,0x95,0xbe,0x00};

//const unsigned char PY_mb_ju    []={"句举巨局具距锯剧居聚拘菊矩沮拒惧鞠狙驹且据柜桔俱车咀疽踞炬倨醵裾屦犋苴窭飓锔椐苣琚掬榘龃趄莒雎遽橘踽榉鞫钜讵枸"};
const unsigned char PY_mb_ju    []={0xe5,0x8f,0xa5,0xe4,0xb8,0xbe,0xe5,0xb7,0xa8,0xe5,0xb1,0x80,0xe5,0x85,0xb7,0xe8,0xb7,0x9d,0xe9,0x94,0xaf,0xe5,0x89,0xa7,0xe5,0xb1,0x85,0xe8,0x81,0x9a,0xe6,0x8b,0x98,0xe8,0x8f,0x8a,0xe7,0x9f,0xa9,0xe6,0xb2,0xae,0xe6,0x8b,0x92,0xe6,0x83,0xa7,0xe9,0x9e,0xa0,0xe7,0x8b,0x99,0xe9,0xa9,0xb9,0xe4,0xb8,0x94,0xe6,0x8d,0xae,0xe6,0x9f,0x9c,0xe6,0xa1,0x94,0xe4,0xbf,0xb1,0xe8,0xbd,0xa6,0xe5,0x92,0x80,0xe7,0x96,0xbd,0xe8,0xb8,0x9e,0xe7,0x82,0xac,0xe5,0x80,0xa8,0xe9,0x86,0xb5,0xe8,0xa3,0xbe,0xe5,0xb1,0xa6,0xe7,0x8a,0x8b,0xe8,0x8b,0xb4,0xe7,0xaa,0xad,0xe9,0xa3,0x93,0xe9,0x94,0x94,0xe6,0xa4,0x90,0xe8,0x8b,0xa3,0xe7,0x90,0x9a,0xe6,0x8e,0xac,0xe6,0xa6,0x98,0xe9,0xbe,0x83,0xe8,0xb6,0x84,0xe8,0x8e,0x92,0xe9,0x9b,0x8e,0xe9,0x81,0xbd,0xe6,0xa9,0x98,0xe8,0xb8,0xbd,0xe6,0xa6,0x89,0xe9,0x9e,0xab,0xe9,0x92,0x9c,0xe8,0xae,0xb5,0xe6,0x9e,0xb8,0x00};

//const unsigned char PY_mb_juan  []={"卷圈倦鹃捐娟眷绢鄄锩蠲镌狷桊涓隽"};
const unsigned char PY_mb_juan  []={0xe5,0x8d,0xb7,0xe5,0x9c,0x88,0xe5,0x80,0xa6,0xe9,0xb9,0x83,0xe6,0x8d,0x90,0xe5,0xa8,0x9f,0xe7,0x9c,0xb7,0xe7,0xbb,0xa2,0xe9,0x84,0x84,0xe9,0x94,0xa9,0xe8,0xa0,0xb2,0xe9,0x95,0x8c,0xe7,0x8b,0xb7,0xe6,0xa1,0x8a,0xe6,0xb6,0x93,0xe9,0x9a,0xbd,0x00};

//const unsigned char PY_mb_jue   []={"决绝觉角爵掘诀撅倔抉攫嚼脚桷噱橛嗟觖劂爝矍镢獗珏崛蕨噘谲蹶孓厥"};
const unsigned char PY_mb_jue   []={0xe5,0x86,0xb3,0xe7,0xbb,0x9d,0xe8,0xa7,0x89,0xe8,0xa7,0x92,0xe7,0x88,0xb5,0xe6,0x8e,0x98,0xe8,0xaf,0x80,0xe6,0x92,0x85,0xe5,0x80,0x94,0xe6,0x8a,0x89,0xe6,0x94,0xab,0xe5,0x9a,0xbc,0xe8,0x84,0x9a,0xe6,0xa1,0xb7,0xe5,0x99,0xb1,0xe6,0xa9,0x9b,0xe5,0x97,0x9f,0xe8,0xa7,0x96,0xe5,0x8a,0x82,0xe7,0x88,0x9d,0xe7,0x9f,0x8d,0xe9,0x95,0xa2,0xe7,0x8d,0x97,0xe7,0x8f,0x8f,0xe5,0xb4,0x9b,0xe8,0x95,0xa8,0xe5,0x99,0x98,0xe8,0xb0,0xb2,0xe8,0xb9,0xb6,0xe5,0xad,0x93,0xe5,0x8e,0xa5,0x00};

//const unsigned char PY_mb_jun   []={"军君均菌俊峻龟竣骏钧浚郡筠麇皲捃"};
const unsigned char PY_mb_jun   []={0xe5,0x86,0x9b,0xe5,0x90,0x9b,0xe5,0x9d,0x87,0xe8,0x8f,0x8c,0xe4,0xbf,0x8a,0xe5,0xb3,0xbb,0xe9,0xbe,0x9f,0xe7,0xab,0xa3,0xe9,0xaa,0x8f,0xe9,0x92,0xa7,0xe6,0xb5,0x9a,0xe9,0x83,0xa1,0xe7,0xad,0xa0,0xe9,0xba,0x87,0xe7,0x9a,0xb2,0xe6,0x8d,0x83,0x00};

//const unsigned char PY_mb_ka    []={"卡喀咯咖胩咔佧"};
const unsigned char PY_mb_ka    []={0xe5,0x8d,0xa1,0xe5,0x96,0x80,0xe5,0x92,0xaf,0xe5,0x92,0x96,0xe8,0x83,0xa9,0xe5,0x92,0x94,0xe4,0xbd,0xa7,0x00};

//const unsigned char PY_mb_kai   []={"开揩凯慨楷垲剀锎铠锴忾恺蒈"};
const unsigned char PY_mb_kai   []={0xe5,0xbc,0x80,0xe6,0x8f,0xa9,0xe5,0x87,0xaf,0xe6,0x85,0xa8,0xe6,0xa5,0xb7,0xe5,0x9e,0xb2,0xe5,0x89,0x80,0xe9,0x94,0x8e,0xe9,0x93,0xa0,0xe9,0x94,0xb4,0xe5,0xbf,0xbe,0xe6,0x81,0xba,0xe8,0x92,0x88,0x00};

//const unsigned char PY_mb_kan   []={"看砍堪刊嵌坎槛勘龛戡侃瞰莰阚"};
const unsigned char PY_mb_kan   []={0xe7,0x9c,0x8b,0xe7,0xa0,0x8d,0xe5,0xa0,0xaa,0xe5,0x88,0x8a,0xe5,0xb5,0x8c,0xe5,0x9d,0x8e,0xe6,0xa7,0x9b,0xe5,0x8b,0x98,0xe9,0xbe,0x9b,0xe6,0x88,0xa1,0xe4,0xbe,0x83,0xe7,0x9e,0xb0,0xe8,0x8e,0xb0,0xe9,0x98,0x9a,0x00};

//const unsigned char PY_mb_kang  []={"抗炕扛糠康慷亢钪闶伉"};
const unsigned char PY_mb_kang  []={0xe6,0x8a,0x97,0xe7,0x82,0x95,0xe6,0x89,0x9b,0xe7,0xb3,0xa0,0xe5,0xba,0xb7,0xe6,0x85,0xb7,0xe4,0xba,0xa2,0xe9,0x92,0xaa,0xe9,0x97,0xb6,0xe4,0xbc,0x89,0x00};

//const unsigned char PY_mb_kao   []={"靠考烤拷栲犒尻铐"};
const unsigned char PY_mb_kao   []={0xe9,0x9d,0xa0,0xe8,0x80,0x83,0xe7,0x83,0xa4,0xe6,0x8b,0xb7,0xe6,0xa0,0xb2,0xe7,0x8a,0x92,0xe5,0xb0,0xbb,0xe9,0x93,0x90,0x00};

//const unsigned char PY_mb_ke    []={"咳可克棵科颗刻课客壳渴苛柯磕坷呵恪岢蝌缂蚵轲窠钶氪颏瞌锞稞珂髁疴嗑溘骒"};
const unsigned char PY_mb_ke    []={0xe5,0x92,0xb3,0xe5,0x8f,0xaf,0xe5,0x85,0x8b,0xe6,0xa3,0xb5,0xe7,0xa7,0x91,0xe9,0xa2,0x97,0xe5,0x88,0xbb,0xe8,0xaf,0xbe,0xe5,0xae,0xa2,0xe5,0xa3,0xb3,0xe6,0xb8,0xb4,0xe8,0x8b,0x9b,0xe6,0x9f,0xaf,0xe7,0xa3,0x95,0xe5,0x9d,0xb7,0xe5,0x91,0xb5,0xe6,0x81,0xaa,0xe5,0xb2,0xa2,0xe8,0x9d,0x8c,0xe7,0xbc,0x82,0xe8,0x9a,0xb5,0xe8,0xbd,0xb2,0xe7,0xaa,0xa0,0xe9,0x92,0xb6,0xe6,0xb0,0xaa,0xe9,0xa2,0x8f,0xe7,0x9e,0x8c,0xe9,0x94,0x9e,0xe7,0xa8,0x9e,0xe7,0x8f,0x82,0xe9,0xab,0x81,0xe7,0x96,0xb4,0xe5,0x97,0x91,0xe6,0xba,0x98,0xe9,0xaa,0x92,0x00};

//const unsigned char PY_mb_ken   []={"肯啃恳垦裉"};
const unsigned char PY_mb_ken   []={0xe8,0x82,0xaf,0xe5,0x95,0x83,0xe6,0x81,0xb3,0xe5,0x9e,0xa6,0xe8,0xa3,0x89,0x00};

//const unsigned char PY_mb_keng  []={"坑吭铿"};
const unsigned char PY_mb_keng  []={0xe5,0x9d,0x91,0xe5,0x90,0xad,0xe9,0x93,0xbf,0x00};

//const unsigned char PY_mb_kong  []={"空孔控恐倥崆箜"};
const unsigned char PY_mb_kong  []={0xe7,0xa9,0xba,0xe5,0xad,0x94,0xe6,0x8e,0xa7,0xe6,0x81,0x90,0xe5,0x80,0xa5,0xe5,0xb4,0x86,0xe7,0xae,0x9c,0x00};

//const unsigned char PY_mb_kou   []={"口扣抠寇蔻芤眍筘叩"};
const unsigned char PY_mb_kou   []={0xe5,0x8f,0xa3,0xe6,0x89,0xa3,0xe6,0x8a,0xa0,0xe5,0xaf,0x87,0xe8,0x94,0xbb,0xe8,0x8a,0xa4,0xe7,0x9c,0x8d,0xe7,0xad,0x98,0xe5,0x8f,0xa9,0x00};

//const unsigned char PY_mb_ku    []={"哭库苦枯裤窟酷刳骷喾堀绔"};
const unsigned char PY_mb_ku    []={0xe5,0x93,0xad,0xe5,0xba,0x93,0xe8,0x8b,0xa6,0xe6,0x9e,0xaf,0xe8,0xa3,0xa4,0xe7,0xaa,0x9f,0xe9,0x85,0xb7,0xe5,0x88,0xb3,0xe9,0xaa,0xb7,0xe5,0x96,0xbe,0xe5,0xa0,0x80,0xe7,0xbb,0x94,0x00};

//const unsigned char PY_mb_kua   []={"跨垮挎夸胯侉"};
const unsigned char PY_mb_kua   []={0xe8,0xb7,0xa8,0xe5,0x9e,0xae,0xe6,0x8c,0x8e,0xe5,0xa4,0xb8,0xe8,0x83,0xaf,0xe4,0xbe,0x89,0x00};

//const unsigned char PY_mb_kuai  []={"快块筷会侩哙蒯浍郐狯脍"};
const unsigned char PY_mb_kuai  []={0xe5,0xbf,0xab,0xe5,0x9d,0x97,0xe7,0xad,0xb7,0xe4,0xbc,0x9a,0xe4,0xbe,0xa9,0xe5,0x93,0x99,0xe8,0x92,0xaf,0xe6,0xb5,0x8d,0xe9,0x83,0x90,0xe7,0x8b,0xaf,0xe8,0x84,0x8d,0x00};

//const unsigned char PY_mb_kuan  []={"宽款髋"};
const unsigned char PY_mb_kuan  []={0xe5,0xae,0xbd,0xe6,0xac,0xbe,0xe9,0xab,0x8b,0x00};

//const unsigned char PY_mb_kuang []={"矿筐狂框况旷匡眶诳邝纩夼诓圹贶哐"};
const unsigned char PY_mb_kuang []={0xe7,0x9f,0xbf,0xe7,0xad,0x90,0xe7,0x8b,0x82,0xe6,0xa1,0x86,0xe5,0x86,0xb5,0xe6,0x97,0xb7,0xe5,0x8c,0xa1,0xe7,0x9c,0xb6,0xe8,0xaf,0xb3,0xe9,0x82,0x9d,0xe7,0xba,0xa9,0xe5,0xa4,0xbc,0xe8,0xaf,0x93,0xe5,0x9c,0xb9,0xe8,0xb4,0xb6,0xe5,0x93,0x90,0x00};

//const unsigned char PY_mb_kui   []={"亏愧奎窥溃葵魁馈盔傀岿匮愦揆睽跬聩篑喹逵暌蒉悝喟馗蝰隗夔"};
const unsigned char PY_mb_kui   []={0xe4,0xba,0x8f,0xe6,0x84,0xa7,0xe5,0xa5,0x8e,0xe7,0xaa,0xa5,0xe6,0xba,0x83,0xe8,0x91,0xb5,0xe9,0xad,0x81,0xe9,0xa6,0x88,0xe7,0x9b,0x94,0xe5,0x82,0x80,0xe5,0xb2,0xbf,0xe5,0x8c,0xae,0xe6,0x84,0xa6,0xe6,0x8f,0x86,0xe7,0x9d,0xbd,0xe8,0xb7,0xac,0xe8,0x81,0xa9,0xe7,0xaf,0x91,0xe5,0x96,0xb9,0xe9,0x80,0xb5,0xe6,0x9a,0x8c,0xe8,0x92,0x89,0xe6,0x82,0x9d,0xe5,0x96,0x9f,0xe9,0xa6,0x97,0xe8,0x9d,0xb0,0xe9,0x9a,0x97,0xe5,0xa4,0x94,0x00};

//const unsigned char PY_mb_kun   []={"捆困昆坤鲲锟髡琨醌阃悃"};
const unsigned char PY_mb_kun   []={0xe6,0x8d,0x86,0xe5,0x9b,0xb0,0xe6,0x98,0x86,0xe5,0x9d,0xa4,0xe9,0xb2,0xb2,0xe9,0x94,0x9f,0xe9,0xab,0xa1,0xe7,0x90,0xa8,0xe9,0x86,0x8c,0xe9,0x98,0x83,0xe6,0x82,0x83,0x00};

//const unsigned char PY_mb_kuo   []={"阔扩括廓适蛞栝"};
const unsigned char PY_mb_kuo   []={0xe9,0x98,0x94,0xe6,0x89,0xa9,0xe6,0x8b,0xac,0xe5,0xbb,0x93,0xe9,0x80,0x82,0xe8,0x9b,0x9e,0xe6,0xa0,0x9d,0x00};

//const unsigned char PY_mb_la    []={"拉啦辣蜡腊喇垃蓝落瘌邋砬剌旯"};
const unsigned char PY_mb_la    []={0xe6,0x8b,0x89,0xe5,0x95,0xa6,0xe8,0xbe,0xa3,0xe8,0x9c,0xa1,0xe8,0x85,0x8a,0xe5,0x96,0x87,0xe5,0x9e,0x83,0xe8,0x93,0x9d,0xe8,0x90,0xbd,0xe7,0x98,0x8c,0xe9,0x82,0x8b,0xe7,0xa0,0xac,0xe5,0x89,0x8c,0xe6,0x97,0xaf,0x00};

//const unsigned char PY_mb_lai   []={"来赖莱崃徕涞濑赉睐铼癞籁"};
const unsigned char PY_mb_lai   []={0xe6,0x9d,0xa5,0xe8,0xb5,0x96,0xe8,0x8e,0xb1,0xe5,0xb4,0x83,0xe5,0xbe,0x95,0xe6,0xb6,0x9e,0xe6,0xbf,0x91,0xe8,0xb5,0x89,0xe7,0x9d,0x90,0xe9,0x93,0xbc,0xe7,0x99,0x9e,0xe7,0xb1,0x81,0x00};

//const unsigned char PY_mb_lan   []={"蓝兰烂拦篮懒栏揽缆滥阑谰婪澜览榄岚褴镧斓罱漤"};
const unsigned char PY_mb_lan   []={0xe8,0x93,0x9d,0xe5,0x85,0xb0,0xe7,0x83,0x82,0xe6,0x8b,0xa6,0xe7,0xaf,0xae,0xe6,0x87,0x92,0xe6,0xa0,0x8f,0xe6,0x8f,0xbd,0xe7,0xbc,0x86,0xe6,0xbb,0xa5,0xe9,0x98,0x91,0xe8,0xb0,0xb0,0xe5,0xa9,0xaa,0xe6,0xbe,0x9c,0xe8,0xa7,0x88,0xe6,0xa6,0x84,0xe5,0xb2,0x9a,0xe8,0xa4,0xb4,0xe9,0x95,0xa7,0xe6,0x96,0x93,0xe7,0xbd,0xb1,0xe6,0xbc,0xa4,0x00};

//const unsigned char PY_mb_lang  []={"浪狼廊郎朗榔琅稂螂莨啷锒阆蒗"};
const unsigned char PY_mb_lang  []={0xe6,0xb5,0xaa,0xe7,0x8b,0xbc,0xe5,0xbb,0x8a,0xe9,0x83,0x8e,0xe6,0x9c,0x97,0xe6,0xa6,0x94,0xe7,0x90,0x85,0xe7,0xa8,0x82,0xe8,0x9e,0x82,0xe8,0x8e,0xa8,0xe5,0x95,0xb7,0xe9,0x94,0x92,0xe9,0x98,0x86,0xe8,0x92,0x97,0x00};

//const unsigned char PY_mb_lao   []={"老捞牢劳烙涝落姥酪络佬潦耢铹醪铑唠栳崂痨"};
const unsigned char PY_mb_lao   []={0xe8,0x80,0x81,0xe6,0x8d,0x9e,0xe7,0x89,0xa2,0xe5,0x8a,0xb3,0xe7,0x83,0x99,0xe6,0xb6,0x9d,0xe8,0x90,0xbd,0xe5,0xa7,0xa5,0xe9,0x85,0xaa,0xe7,0xbb,0x9c,0xe4,0xbd,0xac,0xe6,0xbd,0xa6,0xe8,0x80,0xa2,0xe9,0x93,0xb9,0xe9,0x86,0xaa,0xe9,0x93,0x91,0xe5,0x94,0xa0,0xe6,0xa0,0xb3,0xe5,0xb4,0x82,0xe7,0x97,0xa8,0x00};

//const unsigned char PY_mb_le    []={"了乐勒肋仂叻泐鳓"};
const unsigned char PY_mb_le    []={0xe4,0xba,0x86,0xe4,0xb9,0x90,0xe5,0x8b,0x92,0xe8,0x82,0x8b,0xe4,0xbb,0x82,0xe5,0x8f,0xbb,0xe6,0xb3,0x90,0xe9,0xb3,0x93,0x00};

//const unsigned char PY_mb_lei   []={"类累泪雷垒勒擂蕾肋镭儡磊缧诔耒酹羸嫘檑嘞"};
const unsigned char PY_mb_lei   []={0xe7,0xb1,0xbb,0xe7,0xb4,0xaf,0xe6,0xb3,0xaa,0xe9,0x9b,0xb7,0xe5,0x9e,0x92,0xe5,0x8b,0x92,0xe6,0x93,0x82,0xe8,0x95,0xbe,0xe8,0x82,0x8b,0xe9,0x95,0xad,0xe5,0x84,0xa1,0xe7,0xa3,0x8a,0xe7,0xbc,0xa7,0xe8,0xaf,0x94,0xe8,0x80,0x92,0xe9,0x85,0xb9,0xe7,0xbe,0xb8,0xe5,0xab,0x98,0xe6,0xaa,0x91,0xe5,0x98,0x9e,0x00};

//const unsigned char PY_mb_leng  []={"冷棱楞塄愣"};
const unsigned char PY_mb_leng  []={0xe5,0x86,0xb7,0xe6,0xa3,0xb1,0xe6,0xa5,0x9e,0xe5,0xa1,0x84,0xe6,0x84,0xa3,0x00};

//const unsigned char PY_mb_li    []={"里离力立李例哩理利梨厘礼历丽吏犁黎篱狸漓鲤莉荔栗厉励砾傈俐痢粒沥隶璃俪俚郦坜苈莅蓠鹂笠鳢缡跞蜊锂悝澧粝枥蠡鬲呖砺嫠篥疠疬猁藜溧鲡戾栎唳醴轹詈骊罹逦喱雳黧蛎娌"};
const unsigned char PY_mb_li    []={0xe9,0x87,0x8c,0xe7,0xa6,0xbb,0xe5,0x8a,0x9b,0xe7,0xab,0x8b,0xe6,0x9d,0x8e,0xe4,0xbe,0x8b,0xe5,0x93,0xa9,0xe7,0x90,0x86,0xe5,0x88,0xa9,0xe6,0xa2,0xa8,0xe5,0x8e,0x98,0xe7,0xa4,0xbc,0xe5,0x8e,0x86,0xe4,0xb8,0xbd,0xe5,0x90,0x8f,0xe7,0x8a,0x81,0xe9,0xbb,0x8e,0xe7,0xaf,0xb1,0xe7,0x8b,0xb8,0xe6,0xbc,0x93,0xe9,0xb2,0xa4,0xe8,0x8e,0x89,0xe8,0x8d,0x94,0xe6,0xa0,0x97,0xe5,0x8e,0x89,0xe5,0x8a,0xb1,0xe7,0xa0,0xbe,0xe5,0x82,0x88,0xe4,0xbf,0x90,0xe7,0x97,0xa2,0xe7,0xb2,0x92,0xe6,0xb2,0xa5,0xe9,0x9a,0xb6,0xe7,0x92,0x83,0xe4,0xbf,0xaa,0xe4,0xbf,0x9a,0xe9,0x83,0xa6,0xe5,0x9d,0x9c,0xe8,0x8b,0x88,0xe8,0x8e,0x85,0xe8,0x93,0xa0,0xe9,0xb9,0x82,0xe7,0xac,0xa0,0xe9,0xb3,0xa2,0xe7,0xbc,0xa1,0xe8,0xb7,0x9e,0xe8,0x9c,0x8a,0xe9,0x94,0x82,0xe6,0x82,0x9d,0xe6,0xbe,0xa7,0xe7,0xb2,0x9d,0xe6,0x9e,0xa5,0xe8,0xa0,0xa1,0xe9,0xac,0xb2,0xe5,0x91,0x96,0xe7,0xa0,0xba,0xe5,0xab,0xa0,0xe7,0xaf,0xa5,0xe7,0x96,0xa0,0xe7,0x96,0xac,0xe7,0x8c,0x81,0xe8,0x97,0x9c,0xe6,0xba,0xa7,0xe9,0xb2,0xa1,0xe6,0x88,0xbe,0xe6,0xa0,0x8e,0xe5,0x94,0xb3,0xe9,0x86,0xb4,0xe8,0xbd,0xb9,0xe8,0xa9,0x88,0xe9,0xaa,0x8a,0xe7,0xbd,0xb9,0xe9,0x80,0xa6,0xe5,0x96,0xb1,0xe9,0x9b,0xb3,0xe9,0xbb,0xa7,0xe8,0x9b,0x8e,0xe5,0xa8,0x8c,0x00};

//const unsigned char PY_mb_lia	[]={"俩"};
const unsigned char PY_mb_lia	[]={0xe4,0xbf,0xa9,0x00};

//const unsigned char PY_mb_lian  []={"连联练莲恋脸炼链敛怜廉帘镰涟蠊琏殓蔹鲢奁潋臁裢濂裣楝"};
const unsigned char PY_mb_lian  []={0xe8,0xbf,0x9e,0xe8,0x81,0x94,0xe7,0xbb,0x83,0xe8,0x8e,0xb2,0xe6,0x81,0x8b,0xe8,0x84,0xb8,0xe7,0x82,0xbc,0xe9,0x93,0xbe,0xe6,0x95,0x9b,0xe6,0x80,0x9c,0xe5,0xbb,0x89,0xe5,0xb8,0x98,0xe9,0x95,0xb0,0xe6,0xb6,0x9f,0xe8,0xa0,0x8a,0xe7,0x90,0x8f,0xe6,0xae,0x93,0xe8,0x94,0xb9,0xe9,0xb2,0xa2,0xe5,0xa5,0x81,0xe6,0xbd,0x8b,0xe8,0x87,0x81,0xe8,0xa3,0xa2,0xe6,0xbf,0x82,0xe8,0xa3,0xa3,0xe6,0xa5,0x9d,0x00};

//const unsigned char PY_mb_liang []={"两亮辆凉粮梁量良晾谅俩粱墚靓踉椋魉莨"};
const unsigned char PY_mb_liang []={0xe4,0xb8,0xa4,0xe4,0xba,0xae,0xe8,0xbe,0x86,0xe5,0x87,0x89,0xe7,0xb2,0xae,0xe6,0xa2,0x81,0xe9,0x87,0x8f,0xe8,0x89,0xaf,0xe6,0x99,0xbe,0xe8,0xb0,0x85,0xe4,0xbf,0xa9,0xe7,0xb2,0xb1,0xe5,0xa2,0x9a,0xe9,0x9d,0x93,0xe8,0xb8,0x89,0xe6,0xa4,0x8b,0xe9,0xad,0x89,0xe8,0x8e,0xa8,0x00};

//const unsigned char PY_mb_liao  []={"了料撩聊撂疗廖燎辽僚寥镣潦钌蓼尥寮缭獠鹩嘹"};
const unsigned char PY_mb_liao  []={0xe4,0xba,0x86,0xe6,0x96,0x99,0xe6,0x92,0xa9,0xe8,0x81,0x8a,0xe6,0x92,0x82,0xe7,0x96,0x97,0xe5,0xbb,0x96,0xe7,0x87,0x8e,0xe8,0xbe,0xbd,0xe5,0x83,0x9a,0xe5,0xaf,0xa5,0xe9,0x95,0xa3,0xe6,0xbd,0xa6,0xe9,0x92,0x8c,0xe8,0x93,0xbc,0xe5,0xb0,0xa5,0xe5,0xaf,0xae,0xe7,0xbc,0xad,0xe7,0x8d,0xa0,0xe9,0xb9,0xa9,0xe5,0x98,0xb9,0x00};

//const unsigned char PY_mb_lie   []={"列裂猎劣烈咧埒捩鬣趔躐冽洌"};
const unsigned char PY_mb_lie   []={0xe5,0x88,0x97,0xe8,0xa3,0x82,0xe7,0x8c,0x8e,0xe5,0x8a,0xa3,0xe7,0x83,0x88,0xe5,0x92,0xa7,0xe5,0x9f,0x92,0xe6,0x8d,0xa9,0xe9,0xac,0xa3,0xe8,0xb6,0x94,0xe8,0xba,0x90,0xe5,0x86,0xbd,0xe6,0xb4,0x8c,0x00};

//const unsigned char PY_mb_lin   []={"林临淋邻磷鳞赁吝拎琳霖凛遴嶙蔺粼麟躏辚廪懔瞵檩膦啉"};
const unsigned char PY_mb_lin   []={0xe6,0x9e,0x97,0xe4,0xb8,0xb4,0xe6,0xb7,0x8b,0xe9,0x82,0xbb,0xe7,0xa3,0xb7,0xe9,0xb3,0x9e,0xe8,0xb5,0x81,0xe5,0x90,0x9d,0xe6,0x8b,0x8e,0xe7,0x90,0xb3,0xe9,0x9c,0x96,0xe5,0x87,0x9b,0xe9,0x81,0xb4,0xe5,0xb6,0x99,0xe8,0x94,0xba,0xe7,0xb2,0xbc,0xe9,0xba,0x9f,0xe8,0xba,0x8f,0xe8,0xbe,0x9a,0xe5,0xbb,0xaa,0xe6,0x87,0x94,0xe7,0x9e,0xb5,0xe6,0xaa,0xa9,0xe8,0x86,0xa6,0xe5,0x95,0x89,0x00};

//const unsigned char PY_mb_ling  []={"另令领零铃玲灵岭龄凌陵菱伶羚棱翎蛉苓绫瓴酃呤泠棂柃鲮聆囹"};
const unsigned char PY_mb_ling  []={0xe5,0x8f,0xa6,0xe4,0xbb,0xa4,0xe9,0xa2,0x86,0xe9,0x9b,0xb6,0xe9,0x93,0x83,0xe7,0x8e,0xb2,0xe7,0x81,0xb5,0xe5,0xb2,0xad,0xe9,0xbe,0x84,0xe5,0x87,0x8c,0xe9,0x99,0xb5,0xe8,0x8f,0xb1,0xe4,0xbc,0xb6,0xe7,0xbe,0x9a,0xe6,0xa3,0xb1,0xe7,0xbf,0x8e,0xe8,0x9b,0x89,0xe8,0x8b,0x93,0xe7,0xbb,0xab,0xe7,0x93,0xb4,0xe9,0x85,0x83,0xe5,0x91,0xa4,0xe6,0xb3,0xa0,0xe6,0xa3,0x82,0xe6,0x9f,0x83,0xe9,0xb2,0xae,0xe8,0x81,0x86,0xe5,0x9b,0xb9,0x00};

//const unsigned char PY_mb_liu   []={"六流留刘柳溜硫瘤榴琉馏碌陆绺锍鎏镏浏骝旒鹨熘遛"};
const unsigned char PY_mb_liu   []={0xe5,0x85,0xad,0xe6,0xb5,0x81,0xe7,0x95,0x99,0xe5,0x88,0x98,0xe6,0x9f,0xb3,0xe6,0xba,0x9c,0xe7,0xa1,0xab,0xe7,0x98,0xa4,0xe6,0xa6,0xb4,0xe7,0x90,0x89,0xe9,0xa6,0x8f,0xe7,0xa2,0x8c,0xe9,0x99,0x86,0xe7,0xbb,0xba,0xe9,0x94,0x8d,0xe9,0x8e,0x8f,0xe9,0x95,0x8f,0xe6,0xb5,0x8f,0xe9,0xaa,0x9d,0xe6,0x97,0x92,0xe9,0xb9,0xa8,0xe7,0x86,0x98,0xe9,0x81,0x9b,0x00};

//const unsigned char PY_mb_long  []={"龙拢笼聋隆垄弄咙窿陇垅胧珑茏泷栊癃砻"};
const unsigned char PY_mb_long  []={0xe9,0xbe,0x99,0xe6,0x8b,0xa2,0xe7,0xac,0xbc,0xe8,0x81,0x8b,0xe9,0x9a,0x86,0xe5,0x9e,0x84,0xe5,0xbc,0x84,0xe5,0x92,0x99,0xe7,0xaa,0xbf,0xe9,0x99,0x87,0xe5,0x9e,0x85,0xe8,0x83,0xa7,0xe7,0x8f,0x91,0xe8,0x8c,0x8f,0xe6,0xb3,0xb7,0xe6,0xa0,0x8a,0xe7,0x99,0x83,0xe7,0xa0,0xbb,0x00};

//const unsigned char PY_mb_lou   []={"楼搂漏陋露娄篓偻蝼镂蒌耧髅喽瘘嵝"};
const unsigned char PY_mb_lou   []={0xe6,0xa5,0xbc,0xe6,0x90,0x82,0xe6,0xbc,0x8f,0xe9,0x99,0x8b,0xe9,0x9c,0xb2,0xe5,0xa8,0x84,0xe7,0xaf,0x93,0xe5,0x81,0xbb,0xe8,0x9d,0xbc,0xe9,0x95,0x82,0xe8,0x92,0x8c,0xe8,0x80,0xa7,0xe9,0xab,0x85,0xe5,0x96,0xbd,0xe7,0x98,0x98,0xe5,0xb5,0x9d,0x00};

//const unsigned char PY_mb_lu    []={"路露录鹿陆炉卢鲁卤芦颅庐碌掳绿虏赂戮潞禄麓六鲈栌渌蓼逯泸轳氇簏橹辂垆胪噜"};
const unsigned char PY_mb_lu    []={0xe8,0xb7,0xaf,0xe9,0x9c,0xb2,0xe5,0xbd,0x95,0xe9,0xb9,0xbf,0xe9,0x99,0x86,0xe7,0x82,0x89,0xe5,0x8d,0xa2,0xe9,0xb2,0x81,0xe5,0x8d,0xa4,0xe8,0x8a,0xa6,0xe9,0xa2,0x85,0xe5,0xba,0x90,0xe7,0xa2,0x8c,0xe6,0x8e,0xb3,0xe7,0xbb,0xbf,0xe8,0x99,0x8f,0xe8,0xb5,0x82,0xe6,0x88,0xae,0xe6,0xbd,0x9e,0xe7,0xa6,0x84,0xe9,0xba,0x93,0xe5,0x85,0xad,0xe9,0xb2,0x88,0xe6,0xa0,0x8c,0xe6,0xb8,0x8c,0xe8,0x93,0xbc,0xe9,0x80,0xaf,0xe6,0xb3,0xb8,0xe8,0xbd,0xb3,0xe6,0xb0,0x87,0xe7,0xb0,0x8f,0xe6,0xa9,0xb9,0xe8,0xbe,0x82,0xe5,0x9e,0x86,0xe8,0x83,0xaa,0xe5,0x99,0x9c,0x00};

//const unsigned char PY_mb_luan  []={"乱卵滦峦孪挛栾銮脔娈鸾"};
const unsigned char PY_mb_luan  []={0xe4,0xb9,0xb1,0xe5,0x8d,0xb5,0xe6,0xbb,0xa6,0xe5,0xb3,0xa6,0xe5,0xad,0xaa,0xe6,0x8c,0x9b,0xe6,0xa0,0xbe,0xe9,0x8a,0xae,0xe8,0x84,0x94,0xe5,0xa8,0x88,0xe9,0xb8,0xbe,0x00};

//const unsigned char PY_mb_lue   []={"略掠锊"};
const unsigned char PY_mb_lue   []={0xe7,0x95,0xa5,0xe6,0x8e,0xa0,0xe9,0x94,0x8a,0x00};

//const unsigned char PY_mb_lun   []={"论轮抡伦沦仑纶囵"};
const unsigned char PY_mb_lun   []={0xe8,0xae,0xba,0xe8,0xbd,0xae,0xe6,0x8a,0xa1,0xe4,0xbc,0xa6,0xe6,0xb2,0xa6,0xe4,0xbb,0x91,0xe7,0xba,0xb6,0xe5,0x9b,0xb5,0x00};

//const unsigned char PY_mb_luo   []={"落罗锣裸骡烙箩螺萝洛骆逻络咯荦漯蠃雒倮硌椤捋脶瘰摞泺珞镙猡"};
const unsigned char PY_mb_luo   []={0xe8,0x90,0xbd,0xe7,0xbd,0x97,0xe9,0x94,0xa3,0xe8,0xa3,0xb8,0xe9,0xaa,0xa1,0xe7,0x83,0x99,0xe7,0xae,0xa9,0xe8,0x9e,0xba,0xe8,0x90,0x9d,0xe6,0xb4,0x9b,0xe9,0xaa,0x86,0xe9,0x80,0xbb,0xe7,0xbb,0x9c,0xe5,0x92,0xaf,0xe8,0x8d,0xa6,0xe6,0xbc,0xaf,0xe8,0xa0,0x83,0xe9,0x9b,0x92,0xe5,0x80,0xae,0xe7,0xa1,0x8c,0xe6,0xa4,0xa4,0xe6,0x8d,0x8b,0xe8,0x84,0xb6,0xe7,0x98,0xb0,0xe6,0x91,0x9e,0xe6,0xb3,0xba,0xe7,0x8f,0x9e,0xe9,0x95,0x99,0xe7,0x8c,0xa1,0x00};

//const unsigned char PY_mb_lv    []={"绿率铝驴旅屡滤吕律氯缕侣虑履偻膂榈闾捋褛稆"};
const unsigned char PY_mb_lv    []={0xe7,0xbb,0xbf,0xe7,0x8e,0x87,0xe9,0x93,0x9d,0xe9,0xa9,0xb4,0xe6,0x97,0x85,0xe5,0xb1,0xa1,0xe6,0xbb,0xa4,0xe5,0x90,0x95,0xe5,0xbe,0x8b,0xe6,0xb0,0xaf,0xe7,0xbc,0x95,0xe4,0xbe,0xa3,0xe8,0x99,0x91,0xe5,0xb1,0xa5,0xe5,0x81,0xbb,0xe8,0x86,0x82,0xe6,0xa6,0x88,0xe9,0x97,0xbe,0xe6,0x8d,0x8b,0xe8,0xa4,0x9b,0xe7,0xa8,0x86,0x00};

//const unsigned char PY_mb_ma    []={"吗妈马嘛麻骂抹码玛蚂摩唛蟆犸嬷杩"};
const unsigned char PY_mb_ma    []={0xe5,0x90,0x97,0xe5,0xa6,0x88,0xe9,0xa9,0xac,0xe5,0x98,0x9b,0xe9,0xba,0xbb,0xe9,0xaa,0x82,0xe6,0x8a,0xb9,0xe7,0xa0,0x81,0xe7,0x8e,0x9b,0xe8,0x9a,0x82,0xe6,0x91,0xa9,0xe5,0x94,0x9b,0xe8,0x9f,0x86,0xe7,0x8a,0xb8,0xe5,0xac,0xb7,0xe6,0x9d,0xa9,0x00};

//const unsigned char PY_mb_mai   []={"买卖迈埋麦脉劢霾荬"};
const unsigned char PY_mb_mai   []={0xe4,0xb9,0xb0,0xe5,0x8d,0x96,0xe8,0xbf,0x88,0xe5,0x9f,0x8b,0xe9,0xba,0xa6,0xe8,0x84,0x89,0xe5,0x8a,0xa2,0xe9,0x9c,0xbe,0xe8,0x8d,0xac,0x00};

//const unsigned char PY_mb_man   []={"满慢瞒漫蛮蔓曼馒埋谩幔鳗墁螨镘颟鞔缦熳"};
const unsigned char PY_mb_man   []={0xe6,0xbb,0xa1,0xe6,0x85,0xa2,0xe7,0x9e,0x92,0xe6,0xbc,0xab,0xe8,0x9b,0xae,0xe8,0x94,0x93,0xe6,0x9b,0xbc,0xe9,0xa6,0x92,0xe5,0x9f,0x8b,0xe8,0xb0,0xa9,0xe5,0xb9,0x94,0xe9,0xb3,0x97,0xe5,0xa2,0x81,0xe8,0x9e,0xa8,0xe9,0x95,0x98,0xe9,0xa2,0x9f,0xe9,0x9e,0x94,0xe7,0xbc,0xa6,0xe7,0x86,0xb3,0x00};

//const unsigned char PY_mb_mang  []={"忙芒盲莽茫氓硭邙蟒漭"};
const unsigned char PY_mb_mang  []={0xe5,0xbf,0x99,0xe8,0x8a,0x92,0xe7,0x9b,0xb2,0xe8,0x8e,0xbd,0xe8,0x8c,0xab,0xe6,0xb0,0x93,0xe7,0xa1,0xad,0xe9,0x82,0x99,0xe8,0x9f,0x92,0xe6,0xbc,0xad,0x00};

//const unsigned char PY_mb_mao   []={"毛冒帽猫矛卯貌茂贸铆锚茅耄茆瑁蝥髦懋昴牦瞀峁袤蟊旄泖"};
const unsigned char PY_mb_mao   []={0xe6,0xaf,0x9b,0xe5,0x86,0x92,0xe5,0xb8,0xbd,0xe7,0x8c,0xab,0xe7,0x9f,0x9b,0xe5,0x8d,0xaf,0xe8,0xb2,0x8c,0xe8,0x8c,0x82,0xe8,0xb4,0xb8,0xe9,0x93,0x86,0xe9,0x94,0x9a,0xe8,0x8c,0x85,0xe8,0x80,0x84,0xe8,0x8c,0x86,0xe7,0x91,0x81,0xe8,0x9d,0xa5,0xe9,0xab,0xa6,0xe6,0x87,0x8b,0xe6,0x98,0xb4,0xe7,0x89,0xa6,0xe7,0x9e,0x80,0xe5,0xb3,0x81,0xe8,0xa2,0xa4,0xe8,0x9f,0x8a,0xe6,0x97,0x84,0xe6,0xb3,0x96,0x00};

//const unsigned char PY_mb_me    []={"么麽"};
const unsigned char PY_mb_me    []={0xe4,0xb9,0x88,0xe9,0xba,0xbd,0x00};

//const unsigned char PY_mb_mei   []={"没每煤镁美酶妹枚霉玫眉梅寐昧媒糜媚谜沫嵋猸袂湄浼鹛莓魅镅楣"};
const unsigned char PY_mb_mei   []={0xe6,0xb2,0xa1,0xe6,0xaf,0x8f,0xe7,0x85,0xa4,0xe9,0x95,0x81,0xe7,0xbe,0x8e,0xe9,0x85,0xb6,0xe5,0xa6,0xb9,0xe6,0x9e,0x9a,0xe9,0x9c,0x89,0xe7,0x8e,0xab,0xe7,0x9c,0x89,0xe6,0xa2,0x85,0xe5,0xaf,0x90,0xe6,0x98,0xa7,0xe5,0xaa,0x92,0xe7,0xb3,0x9c,0xe5,0xaa,0x9a,0xe8,0xb0,0x9c,0xe6,0xb2,0xab,0xe5,0xb5,0x8b,0xe7,0x8c,0xb8,0xe8,0xa2,0x82,0xe6,0xb9,0x84,0xe6,0xb5,0xbc,0xe9,0xb9,0x9b,0xe8,0x8e,0x93,0xe9,0xad,0x85,0xe9,0x95,0x85,0xe6,0xa5,0xa3,0x00};

//const unsigned char PY_mb_men   []={"门们闷扪焖懑钔"};
const unsigned char PY_mb_men   []={0xe9,0x97,0xa8,0xe4,0xbb,0xac,0xe9,0x97,0xb7,0xe6,0x89,0xaa,0xe7,0x84,0x96,0xe6,0x87,0x91,0xe9,0x92,0x94,0x00};

//const unsigned char PY_mb_meng  []={"猛梦蒙锰孟盟檬萌氓礞蜢勐懵甍蠓虻朦艋艨瞢"};
const unsigned char PY_mb_meng  []={0xe7,0x8c,0x9b,0xe6,0xa2,0xa6,0xe8,0x92,0x99,0xe9,0x94,0xb0,0xe5,0xad,0x9f,0xe7,0x9b,0x9f,0xe6,0xaa,0xac,0xe8,0x90,0x8c,0xe6,0xb0,0x93,0xe7,0xa4,0x9e,0xe8,0x9c,0xa2,0xe5,0x8b,0x90,0xe6,0x87,0xb5,0xe7,0x94,0x8d,0xe8,0xa0,0x93,0xe8,0x99,0xbb,0xe6,0x9c,0xa6,0xe8,0x89,0x8b,0xe8,0x89,0xa8,0xe7,0x9e,0xa2,0x00};

//const unsigned char PY_mb_mi    []={"米密迷眯蜜谜觅秘弥幂靡糜泌醚蘼縻咪汨麋祢猕弭谧芈脒宓敉嘧糸"};
const unsigned char PY_mb_mi    []={0xe7,0xb1,0xb3,0xe5,0xaf,0x86,0xe8,0xbf,0xb7,0xe7,0x9c,0xaf,0xe8,0x9c,0x9c,0xe8,0xb0,0x9c,0xe8,0xa7,0x85,0xe7,0xa7,0x98,0xe5,0xbc,0xa5,0xe5,0xb9,0x82,0xe9,0x9d,0xa1,0xe7,0xb3,0x9c,0xe6,0xb3,0x8c,0xe9,0x86,0x9a,0xe8,0x98,0xbc,0xe7,0xb8,0xbb,0xe5,0x92,0xaa,0xe6,0xb1,0xa8,0xe9,0xba,0x8b,0xe7,0xa5,0xa2,0xe7,0x8c,0x95,0xe5,0xbc,0xad,0xe8,0xb0,0xa7,0xe8,0x8a,0x88,0xe8,0x84,0x92,0xe5,0xae,0x93,0xe6,0x95,0x89,0xe5,0x98,0xa7,0xe7,0xb3,0xb8,0x00};

//const unsigned char PY_mb_mian  []={"面棉免绵眠缅勉冕娩腼湎眄沔黾渑"};
const unsigned char PY_mb_mian  []={0xe9,0x9d,0xa2,0xe6,0xa3,0x89,0xe5,0x85,0x8d,0xe7,0xbb,0xb5,0xe7,0x9c,0xa0,0xe7,0xbc,0x85,0xe5,0x8b,0x89,0xe5,0x86,0x95,0xe5,0xa8,0xa9,0xe8,0x85,0xbc,0xe6,0xb9,0x8e,0xe7,0x9c,0x84,0xe6,0xb2,0x94,0xe9,0xbb,0xbe,0xe6,0xb8,0x91,0x00};

//const unsigned char PY_mb_miao  []={"秒苗庙妙描瞄藐渺眇缪缈邈淼喵杪鹋"};
const unsigned char PY_mb_miao  []={0xe7,0xa7,0x92,0xe8,0x8b,0x97,0xe5,0xba,0x99,0xe5,0xa6,0x99,0xe6,0x8f,0x8f,0xe7,0x9e,0x84,0xe8,0x97,0x90,0xe6,0xb8,0xba,0xe7,0x9c,0x87,0xe7,0xbc,0xaa,0xe7,0xbc,0x88,0xe9,0x82,0x88,0xe6,0xb7,0xbc,0xe5,0x96,0xb5,0xe6,0x9d,0xaa,0xe9,0xb9,0x8b,0x00};

//const unsigned char PY_mb_mie   []={"灭蔑咩篾蠛乜"};
const unsigned char PY_mb_mie   []={0xe7,0x81,0xad,0xe8,0x94,0x91,0xe5,0x92,0xa9,0xe7,0xaf,0xbe,0xe8,0xa0,0x9b,0xe4,0xb9,0x9c,0x00};

//const unsigned char PY_mb_min   []={"民抿敏闽皿悯珉愍缗闵玟苠泯黾鳘岷"};
const unsigned char PY_mb_min   []={0xe6,0xb0,0x91,0xe6,0x8a,0xbf,0xe6,0x95,0x8f,0xe9,0x97,0xbd,0xe7,0x9a,0xbf,0xe6,0x82,0xaf,0xe7,0x8f,0x89,0xe6,0x84,0x8d,0xe7,0xbc,0x97,0xe9,0x97,0xb5,0xe7,0x8e,0x9f,0xe8,0x8b,0xa0,0xe6,0xb3,0xaf,0xe9,0xbb,0xbe,0xe9,0xb3,0x98,0xe5,0xb2,0xb7,0x00};

//const unsigned char PY_mb_ming  []={"名明命鸣铭螟盟冥瞑暝茗溟酩"};
const unsigned char PY_mb_ming  []={0xe5,0x90,0x8d,0xe6,0x98,0x8e,0xe5,0x91,0xbd,0xe9,0xb8,0xa3,0xe9,0x93,0xad,0xe8,0x9e,0x9f,0xe7,0x9b,0x9f,0xe5,0x86,0xa5,0xe7,0x9e,0x91,0xe6,0x9a,0x9d,0xe8,0x8c,0x97,0xe6,0xba,0x9f,0xe9,0x85,0xa9,0x00};

//const unsigned char PY_mb_miu   []={"谬缪"};
const unsigned char PY_mb_miu   []={0xe8,0xb0,0xac,0xe7,0xbc,0xaa,0x00};

//const unsigned char PY_mb_mo    []={"摸磨抹末膜墨没莫默魔模摩摹漠陌脉沫万无冒寞秣蓦麽茉嘿嬷蘑瘼殁镆嫫谟貊貘馍耱"};
const unsigned char PY_mb_mo    []={0xe6,0x91,0xb8,0xe7,0xa3,0xa8,0xe6,0x8a,0xb9,0xe6,0x9c,0xab,0xe8,0x86,0x9c,0xe5,0xa2,0xa8,0xe6,0xb2,0xa1,0xe8,0x8e,0xab,0xe9,0xbb,0x98,0xe9,0xad,0x94,0xe6,0xa8,0xa1,0xe6,0x91,0xa9,0xe6,0x91,0xb9,0xe6,0xbc,0xa0,0xe9,0x99,0x8c,0xe8,0x84,0x89,0xe6,0xb2,0xab,0xe4,0xb8,0x87,0xe6,0x97,0xa0,0xe5,0x86,0x92,0xe5,0xaf,0x9e,0xe7,0xa7,0xa3,0xe8,0x93,0xa6,0xe9,0xba,0xbd,0xe8,0x8c,0x89,0xe5,0x98,0xbf,0xe5,0xac,0xb7,0xe8,0x98,0x91,0xe7,0x98,0xbc,0xe6,0xae,0x81,0xe9,0x95,0x86,0xe5,0xab,0xab,0xe8,0xb0,0x9f,0xe8,0xb2,0x8a,0xe8,0xb2,0x98,0xe9,0xa6,0x8d,0xe8,0x80,0xb1,0x00};

//const unsigned char PY_mb_mou   []={"某谋牟眸蛑鍪侔缪哞"};
const unsigned char PY_mb_mou   []={0xe6,0x9f,0x90,0xe8,0xb0,0x8b,0xe7,0x89,0x9f,0xe7,0x9c,0xb8,0xe8,0x9b,0x91,0xe9,0x8d,0xaa,0xe4,0xbe,0x94,0xe7,0xbc,0xaa,0xe5,0x93,0x9e,0x00};

//const unsigned char PY_mb_mu    []={"木母亩幕目墓牧牟模穆暮牡拇募慕睦姆姥钼毪坶沐仫苜"};
const unsigned char PY_mb_mu    []={0xe6,0x9c,0xa8,0xe6,0xaf,0x8d,0xe4,0xba,0xa9,0xe5,0xb9,0x95,0xe7,0x9b,0xae,0xe5,0xa2,0x93,0xe7,0x89,0xa7,0xe7,0x89,0x9f,0xe6,0xa8,0xa1,0xe7,0xa9,0x86,0xe6,0x9a,0xae,0xe7,0x89,0xa1,0xe6,0x8b,0x87,0xe5,0x8b,0x9f,0xe6,0x85,0x95,0xe7,0x9d,0xa6,0xe5,0xa7,0x86,0xe5,0xa7,0xa5,0xe9,0x92,0xbc,0xe6,0xaf,0xaa,0xe5,0x9d,0xb6,0xe6,0xb2,0x90,0xe4,0xbb,0xab,0xe8,0x8b,0x9c,0x00};

//const unsigned char PY_mb_na    []={"那拿哪纳钠娜呐南衲捺镎肭"};
const unsigned char PY_mb_na    []={0xe9,0x82,0xa3,0xe6,0x8b,0xbf,0xe5,0x93,0xaa,0xe7,0xba,0xb3,0xe9,0x92,0xa0,0xe5,0xa8,0x9c,0xe5,0x91,0x90,0xe5,0x8d,0x97,0xe8,0xa1,0xb2,0xe6,0x8d,0xba,0xe9,0x95,0x8e,0xe8,0x82,0xad,0x00};

//const unsigned char PY_mb_nai   []={"乃耐奶奈氖哪萘艿柰鼐佴"};
const unsigned char PY_mb_nai   []={0xe4,0xb9,0x83,0xe8,0x80,0x90,0xe5,0xa5,0xb6,0xe5,0xa5,0x88,0xe6,0xb0,0x96,0xe5,0x93,0xaa,0xe8,0x90,0x98,0xe8,0x89,0xbf,0xe6,0x9f,0xb0,0xe9,0xbc,0x90,0xe4,0xbd,0xb4,0x00};

//const unsigned char PY_mb_nan   []={"难南男赧囡蝻楠喃腩"};
const unsigned char PY_mb_nan   []={0xe9,0x9a,0xbe,0xe5,0x8d,0x97,0xe7,0x94,0xb7,0xe8,0xb5,0xa7,0xe5,0x9b,0xa1,0xe8,0x9d,0xbb,0xe6,0xa5,0xa0,0xe5,0x96,0x83,0xe8,0x85,0xa9,0x00};

//const unsigned char PY_mb_nang  []={"囊馕曩囔攮"};
const unsigned char PY_mb_nang  []={0xe5,0x9b,0x8a,0xe9,0xa6,0x95,0xe6,0x9b,0xa9,0xe5,0x9b,0x94,0xe6,0x94,0xae,0x00};

//const unsigned char PY_mb_nao   []={"闹脑恼挠淖孬铙瑙垴呶蛲猱硇"};
const unsigned char PY_mb_nao   []={0xe9,0x97,0xb9,0xe8,0x84,0x91,0xe6,0x81,0xbc,0xe6,0x8c,0xa0,0xe6,0xb7,0x96,0xe5,0xad,0xac,0xe9,0x93,0x99,0xe7,0x91,0x99,0xe5,0x9e,0xb4,0xe5,0x91,0xb6,0xe8,0x9b,0xb2,0xe7,0x8c,0xb1,0xe7,0xa1,0x87,0x00};

//const unsigned char PY_mb_ne    []={"呢哪那呐讷"};
const unsigned char PY_mb_ne    []={0xe5,0x91,0xa2,0xe5,0x93,0xaa,0xe9,0x82,0xa3,0xe5,0x91,0x90,0xe8,0xae,0xb7,0x00};

//const unsigned char PY_mb_nei   []={"内哪馁那"};
const unsigned char PY_mb_nei   []={0xe5,0x86,0x85,0xe5,0x93,0xaa,0xe9,0xa6,0x81,0xe9,0x82,0xa3,0x00};

//const unsigned char PY_mb_nen   []={"嫩恁"};
const unsigned char PY_mb_nen   []={0xe5,0xab,0xa9,0xe6,0x81,0x81,0x00};

//const unsigned char PY_mb_neng  []={"能"};
const unsigned char PY_mb_neng  []={0xe8,0x83,0xbd,0x00};

//const unsigned char PY_mb_ni    []={"你泥拟腻逆呢溺倪尼匿妮霓铌昵坭祢猊伲怩鲵睨旎"};
const unsigned char PY_mb_ni    []={0xe4,0xbd,0xa0,0xe6,0xb3,0xa5,0xe6,0x8b,0x9f,0xe8,0x85,0xbb,0xe9,0x80,0x86,0xe5,0x91,0xa2,0xe6,0xba,0xba,0xe5,0x80,0xaa,0xe5,0xb0,0xbc,0xe5,0x8c,0xbf,0xe5,0xa6,0xae,0xe9,0x9c,0x93,0xe9,0x93,0x8c,0xe6,0x98,0xb5,0xe5,0x9d,0xad,0xe7,0xa5,0xa2,0xe7,0x8c,0x8a,0xe4,0xbc,0xb2,0xe6,0x80,0xa9,0xe9,0xb2,0xb5,0xe7,0x9d,0xa8,0xe6,0x97,0x8e,0x00};

//const unsigned char PY_mb_nian  []={"年念捻撵拈碾蔫粘廿黏辇鲇鲶埝"};
const unsigned char PY_mb_nian  []={0xe5,0xb9,0xb4,0xe5,0xbf,0xb5,0xe6,0x8d,0xbb,0xe6,0x92,0xb5,0xe6,0x8b,0x88,0xe7,0xa2,0xbe,0xe8,0x94,0xab,0xe7,0xb2,0x98,0xe5,0xbb,0xbf,0xe9,0xbb,0x8f,0xe8,0xbe,0x87,0xe9,0xb2,0x87,0xe9,0xb2,0xb6,0xe5,0x9f,0x9d,0x00};

//const unsigned char PY_mb_niang []={"娘酿"};
const unsigned char PY_mb_niang []={0xe5,0xa8,0x98,0xe9,0x85,0xbf,0x00};

//const unsigned char PY_mb_niao  []={"鸟尿袅茑脲嬲"};
const unsigned char PY_mb_niao  []={0xe9,0xb8,0x9f,0xe5,0xb0,0xbf,0xe8,0xa2,0x85,0xe8,0x8c,0x91,0xe8,0x84,0xb2,0xe5,0xac,0xb2,0x00};

//const unsigned char PY_mb_nie   []={"捏镍聂孽涅镊啮陧蘖嗫臬蹑颞乜"};
const unsigned char PY_mb_nie   []={0xe6,0x8d,0x8f,0xe9,0x95,0x8d,0xe8,0x81,0x82,0xe5,0xad,0xbd,0xe6,0xb6,0x85,0xe9,0x95,0x8a,0xe5,0x95,0xae,0xe9,0x99,0xa7,0xe8,0x98,0x96,0xe5,0x97,0xab,0xe8,0x87,0xac,0xe8,0xb9,0x91,0xe9,0xa2,0x9e,0xe4,0xb9,0x9c,0x00};

//const unsigned char PY_mb_nin   []={"您恁"};
const unsigned char PY_mb_nin   []={0xe6,0x82,0xa8,0xe6,0x81,0x81,0x00};

//const unsigned char PY_mb_ning  []={"拧凝宁柠狞泞佞甯咛聍"};
const unsigned char PY_mb_ning  []={0xe6,0x8b,0xa7,0xe5,0x87,0x9d,0xe5,0xae,0x81,0xe6,0x9f,0xa0,0xe7,0x8b,0x9e,0xe6,0xb3,0x9e,0xe4,0xbd,0x9e,0xe7,0x94,0xaf,0xe5,0x92,0x9b,0xe8,0x81,0x8d,0x00};

//const unsigned char PY_mb_niu   []={"牛扭纽钮狃忸妞拗"};
const unsigned char PY_mb_niu   []={0xe7,0x89,0x9b,0xe6,0x89,0xad,0xe7,0xba,0xbd,0xe9,0x92,0xae,0xe7,0x8b,0x83,0xe5,0xbf,0xb8,0xe5,0xa6,0x9e,0xe6,0x8b,0x97,0x00};

//const unsigned char PY_mb_nong  []={"弄浓农脓哝侬"};
const unsigned char PY_mb_nong  []={0xe5,0xbc,0x84,0xe6,0xb5,0x93,0xe5,0x86,0x9c,0xe8,0x84,0x93,0xe5,0x93,0x9d,0xe4,0xbe,0xac,0x00};

//const unsigned char PY_mb_nu    []={"怒努奴孥胬驽弩"};
const unsigned char PY_mb_nu    []={0xe6,0x80,0x92,0xe5,0x8a,0xaa,0xe5,0xa5,0xb4,0xe5,0xad,0xa5,0xe8,0x83,0xac,0xe9,0xa9,0xbd,0xe5,0xbc,0xa9,0x00};

//const unsigned char PY_mb_nuan  []={"暖"};
const unsigned char PY_mb_nuan  []={0xe6,0x9a,0x96,0x00};

//const unsigned char PY_mb_nue   []={"虐疟谑"};
const unsigned char PY_mb_nue   []={0xe8,0x99,0x90,0xe7,0x96,0x9f,0xe8,0xb0,0x91,0x00};

//const unsigned char PY_mb_nuo   []={"挪诺懦糯娜喏傩锘搦"};
const unsigned char PY_mb_nuo   []={0xe6,0x8c,0xaa,0xe8,0xaf,0xba,0xe6,0x87,0xa6,0xe7,0xb3,0xaf,0xe5,0xa8,0x9c,0xe5,0x96,0x8f,0xe5,0x82,0xa9,0xe9,0x94,0x98,0xe6,0x90,0xa6,0x00};

//const unsigned char PY_mb_nv    []={"女钕恧衄"};
const unsigned char PY_mb_nv    []={0xe5,0xa5,0xb3,0xe9,0x92,0x95,0xe6,0x81,0xa7,0xe8,0xa1,0x84,0x00};

//const unsigned char PY_mb_o     []={"哦喔噢"};
const unsigned char PY_mb_o     []={0xe5,0x93,0xa6,0xe5,0x96,0x94,0xe5,0x99,0xa2,0x00};

//const unsigned char PY_mb_ou    []={"偶呕欧藕鸥区沤殴怄瓯讴耦"};
const unsigned char PY_mb_ou    []={0xe5,0x81,0xb6,0xe5,0x91,0x95,0xe6,0xac,0xa7,0xe8,0x97,0x95,0xe9,0xb8,0xa5,0xe5,0x8c,0xba,0xe6,0xb2,0xa4,0xe6,0xae,0xb4,0xe6,0x80,0x84,0xe7,0x93,0xaf,0xe8,0xae,0xb4,0xe8,0x80,0xa6,0x00};

//const unsigned char PY_mb_pa    []={"怕爬趴啪耙扒帕琶派筢杷葩"};
const unsigned char PY_mb_pa    []={0xe6,0x80,0x95,0xe7,0x88,0xac,0xe8,0xb6,0xb4,0xe5,0x95,0xaa,0xe8,0x80,0x99,0xe6,0x89,0x92,0xe5,0xb8,0x95,0xe7,0x90,0xb6,0xe6,0xb4,0xbe,0xe7,0xad,0xa2,0xe6,0x9d,0xb7,0xe8,0x91,0xa9,0x00};

//const unsigned char PY_mb_pai   []={"派排拍牌迫徘湃哌俳蒎"};
const unsigned char PY_mb_pai   []={0xe6,0xb4,0xbe,0xe6,0x8e,0x92,0xe6,0x8b,0x8d,0xe7,0x89,0x8c,0xe8,0xbf,0xab,0xe5,0xbe,0x98,0xe6,0xb9,0x83,0xe5,0x93,0x8c,0xe4,0xbf,0xb3,0xe8,0x92,0x8e,0x00};

//const unsigned char PY_mb_pan   []={"盘盼判攀畔潘叛磐番般胖襻蟠袢泮拚爿蹒"};
const unsigned char PY_mb_pan   []={0xe7,0x9b,0x98,0xe7,0x9b,0xbc,0xe5,0x88,0xa4,0xe6,0x94,0x80,0xe7,0x95,0x94,0xe6,0xbd,0x98,0xe5,0x8f,0x9b,0xe7,0xa3,0x90,0xe7,0x95,0xaa,0xe8,0x88,0xac,0xe8,0x83,0x96,0xe8,0xa5,0xbb,0xe8,0x9f,0xa0,0xe8,0xa2,0xa2,0xe6,0xb3,0xae,0xe6,0x8b,0x9a,0xe7,0x88,0xbf,0xe8,0xb9,0x92,0x00};

//const unsigned char PY_mb_pang  []={"旁胖耪庞乓膀磅滂彷逄螃"};
const unsigned char PY_mb_pang  []={0xe6,0x97,0x81,0xe8,0x83,0x96,0xe8,0x80,0xaa,0xe5,0xba,0x9e,0xe4,0xb9,0x93,0xe8,0x86,0x80,0xe7,0xa3,0x85,0xe6,0xbb,0x82,0xe5,0xbd,0xb7,0xe9,0x80,0x84,0xe8,0x9e,0x83,0x00};

//const unsigned char PY_mb_pao   []={"跑抛炮泡刨袍咆狍匏庖疱脬"};
const unsigned char PY_mb_pao   []={0xe8,0xb7,0x91,0xe6,0x8a,0x9b,0xe7,0x82,0xae,0xe6,0xb3,0xa1,0xe5,0x88,0xa8,0xe8,0xa2,0x8d,0xe5,0x92,0x86,0xe7,0x8b,0x8d,0xe5,0x8c,0x8f,0xe5,0xba,0x96,0xe7,0x96,0xb1,0xe8,0x84,0xac,0x00};

//const unsigned char PY_mb_pei   []={"陪配赔呸胚佩培沛裴旆锫帔醅霈辔"};
const unsigned char PY_mb_pei   []={0xe9,0x99,0xaa,0xe9,0x85,0x8d,0xe8,0xb5,0x94,0xe5,0x91,0xb8,0xe8,0x83,0x9a,0xe4,0xbd,0xa9,0xe5,0x9f,0xb9,0xe6,0xb2,0x9b,0xe8,0xa3,0xb4,0xe6,0x97,0x86,0xe9,0x94,0xab,0xe5,0xb8,0x94,0xe9,0x86,0x85,0xe9,0x9c,0x88,0xe8,0xbe,0x94,0x00};

//const unsigned char PY_mb_pen   []={"喷盆湓"};
const unsigned char PY_mb_pen   []={0xe5,0x96,0xb7,0xe7,0x9b,0x86,0xe6,0xb9,0x93,0x00};

//const unsigned char PY_mb_peng  []={"碰捧棚砰蓬朋彭鹏烹硼膨抨澎篷怦堋蟛嘭"};
const unsigned char PY_mb_peng  []={0xe7,0xa2,0xb0,0xe6,0x8d,0xa7,0xe6,0xa3,0x9a,0xe7,0xa0,0xb0,0xe8,0x93,0xac,0xe6,0x9c,0x8b,0xe5,0xbd,0xad,0xe9,0xb9,0x8f,0xe7,0x83,0xb9,0xe7,0xa1,0xbc,0xe8,0x86,0xa8,0xe6,0x8a,0xa8,0xe6,0xbe,0x8e,0xe7,0xaf,0xb7,0xe6,0x80,0xa6,0xe5,0xa0,0x8b,0xe8,0x9f,0x9b,0xe5,0x98,0xad,0x00};

//const unsigned char PY_mb_pi    []={"批皮披匹劈辟坯屁脾僻疲痞霹琵毗啤譬砒否貔丕圮媲癖仳擗郫甓枇睥蜱鼙邳吡陂铍庀罴埤纰陴淠噼蚍裨"};
const unsigned char PY_mb_pi    []={0xe6,0x89,0xb9,0xe7,0x9a,0xae,0xe6,0x8a,0xab,0xe5,0x8c,0xb9,0xe5,0x8a,0x88,0xe8,0xbe,0x9f,0xe5,0x9d,0xaf,0xe5,0xb1,0x81,0xe8,0x84,0xbe,0xe5,0x83,0xbb,0xe7,0x96,0xb2,0xe7,0x97,0x9e,0xe9,0x9c,0xb9,0xe7,0x90,0xb5,0xe6,0xaf,0x97,0xe5,0x95,0xa4,0xe8,0xad,0xac,0xe7,0xa0,0x92,0xe5,0x90,0xa6,0xe8,0xb2,0x94,0xe4,0xb8,0x95,0xe5,0x9c,0xae,0xe5,0xaa,0xb2,0xe7,0x99,0x96,0xe4,0xbb,0xb3,0xe6,0x93,0x97,0xe9,0x83,0xab,0xe7,0x94,0x93,0xe6,0x9e,0x87,0xe7,0x9d,0xa5,0xe8,0x9c,0xb1,0xe9,0xbc,0x99,0xe9,0x82,0xb3,0xe5,0x90,0xa1,0xe9,0x99,0x82,0xe9,0x93,0x8d,0xe5,0xba,0x80,0xe7,0xbd,0xb4,0xe5,0x9f,0xa4,0xe7,0xba,0xb0,0xe9,0x99,0xb4,0xe6,0xb7,0xa0,0xe5,0x99,0xbc,0xe8,0x9a,0x8d,0xe8,0xa3,0xa8,0x00};

//const unsigned char PY_mb_pian  []={"片篇骗偏便扁翩缏犏骈胼蹁谝"};
const unsigned char PY_mb_pian  []={0xe7,0x89,0x87,0xe7,0xaf,0x87,0xe9,0xaa,0x97,0xe5,0x81,0x8f,0xe4,0xbe,0xbf,0xe6,0x89,0x81,0xe7,0xbf,0xa9,0xe7,0xbc,0x8f,0xe7,0x8a,0x8f,0xe9,0xaa,0x88,0xe8,0x83,0xbc,0xe8,0xb9,0x81,0xe8,0xb0,0x9d,0x00};

//const unsigned char PY_mb_piao  []={"票飘漂瓢朴螵莩嫖瞟殍缥嘌骠剽"};
const unsigned char PY_mb_piao  []={0xe7,0xa5,0xa8,0xe9,0xa3,0x98,0xe6,0xbc,0x82,0xe7,0x93,0xa2,0xe6,0x9c,0xb4,0xe8,0x9e,0xb5,0xe8,0x8e,0xa9,0xe5,0xab,0x96,0xe7,0x9e,0x9f,0xe6,0xae,0x8d,0xe7,0xbc,0xa5,0xe5,0x98,0x8c,0xe9,0xaa,0xa0,0xe5,0x89,0xbd,0x00};

//const unsigned char PY_mb_pie   []={"瞥撇苤氕"};
const unsigned char PY_mb_pie   []={0xe7,0x9e,0xa5,0xe6,0x92,0x87,0xe8,0x8b,0xa4,0xe6,0xb0,0x95,0x00};

//const unsigned char PY_mb_pin   []={"品贫聘拼频嫔榀姘牝颦"};
const unsigned char PY_mb_pin   []={0xe5,0x93,0x81,0xe8,0xb4,0xab,0xe8,0x81,0x98,0xe6,0x8b,0xbc,0xe9,0xa2,0x91,0xe5,0xab,0x94,0xe6,0xa6,0x80,0xe5,0xa7,0x98,0xe7,0x89,0x9d,0xe9,0xa2,0xa6,0x00};

//const unsigned char PY_mb_ping  []={"平凭瓶评屏乒萍苹坪冯娉鲆枰俜"};
const unsigned char PY_mb_ping  []={0xe5,0xb9,0xb3,0xe5,0x87,0xad,0xe7,0x93,0xb6,0xe8,0xaf,0x84,0xe5,0xb1,0x8f,0xe4,0xb9,0x92,0xe8,0x90,0x8d,0xe8,0x8b,0xb9,0xe5,0x9d,0xaa,0xe5,0x86,0xaf,0xe5,0xa8,0x89,0xe9,0xb2,0x86,0xe6,0x9e,0xb0,0xe4,0xbf,0x9c,0x00};

//const unsigned char PY_mb_po    []={"破坡颇婆泼迫泊魄朴繁粕笸皤钋陂鄱攴叵珀钷"};
const unsigned char PY_mb_po    []={0xe7,0xa0,0xb4,0xe5,0x9d,0xa1,0xe9,0xa2,0x87,0xe5,0xa9,0x86,0xe6,0xb3,0xbc,0xe8,0xbf,0xab,0xe6,0xb3,0x8a,0xe9,0xad,0x84,0xe6,0x9c,0xb4,0xe7,0xb9,0x81,0xe7,0xb2,0x95,0xe7,0xac,0xb8,0xe7,0x9a,0xa4,0xe9,0x92,0x8b,0xe9,0x99,0x82,0xe9,0x84,0xb1,0xe6,0x94,0xb4,0xe5,0x8f,0xb5,0xe7,0x8f,0x80,0xe9,0x92,0xb7,0x00};

//const unsigned char PY_mb_pou   []={"剖掊裒"};
const unsigned char PY_mb_pou   []={0xe5,0x89,0x96,0xe6,0x8e,0x8a,0xe8,0xa3,0x92,0x00};

//const unsigned char PY_mb_pu    []={"扑铺谱脯仆蒲葡朴菩曝莆瀑埔圃浦堡普暴镨噗匍溥濮氆蹼璞镤僕"};
const unsigned char PY_mb_pu    []={0xe6,0x89,0x91,0xe9,0x93,0xba,0xe8,0xb0,0xb1,0xe8,0x84,0xaf,0xe4,0xbb,0x86,0xe8,0x92,0xb2,0xe8,0x91,0xa1,0xe6,0x9c,0xb4,0xe8,0x8f,0xa9,0xe6,0x9b,0x9d,0xe8,0x8e,0x86,0xe7,0x80,0x91,0xe5,0x9f,0x94,0xe5,0x9c,0x83,0xe6,0xb5,0xa6,0xe5,0xa0,0xa1,0xe6,0x99,0xae,0xe6,0x9a,0xb4,0xe9,0x95,0xa8,0xe5,0x99,0x97,0xe5,0x8c,0x8d,0xe6,0xba,0xa5,0xe6,0xbf,0xae,0xe6,0xb0,0x86,0xe8,0xb9,0xbc,0xe7,0x92,0x9e,0xe9,0x95,0xa4,0xe5,0x83,0x95,0x00};

//const unsigned char PY_mb_qi    []={"起其七气期齐器妻骑汽棋奇欺漆启戚柒岂砌弃泣祁凄企乞契歧祈栖畦脐崎稽迄缉沏讫旗祺颀骐屺岐蹊萁蕲桤憩芪荠萋芑汔亟鳍俟槭嘁蛴綦亓欹琪麒琦蜞圻杞葺碛淇祗耆绮"};
const unsigned char PY_mb_qi    []={0xe8,0xb5,0xb7,0xe5,0x85,0xb6,0xe4,0xb8,0x83,0xe6,0xb0,0x94,0xe6,0x9c,0x9f,0xe9,0xbd,0x90,0xe5,0x99,0xa8,0xe5,0xa6,0xbb,0xe9,0xaa,0x91,0xe6,0xb1,0xbd,0xe6,0xa3,0x8b,0xe5,0xa5,0x87,0xe6,0xac,0xba,0xe6,0xbc,0x86,0xe5,0x90,0xaf,0xe6,0x88,0x9a,0xe6,0x9f,0x92,0xe5,0xb2,0x82,0xe7,0xa0,0x8c,0xe5,0xbc,0x83,0xe6,0xb3,0xa3,0xe7,0xa5,0x81,0xe5,0x87,0x84,0xe4,0xbc,0x81,0xe4,0xb9,0x9e,0xe5,0xa5,0x91,0xe6,0xad,0xa7,0xe7,0xa5,0x88,0xe6,0xa0,0x96,0xe7,0x95,0xa6,0xe8,0x84,0x90,0xe5,0xb4,0x8e,0xe7,0xa8,0xbd,0xe8,0xbf,0x84,0xe7,0xbc,0x89,0xe6,0xb2,0x8f,0xe8,0xae,0xab,0xe6,0x97,0x97,0xe7,0xa5,0xba,0xe9,0xa2,0x80,0xe9,0xaa,0x90,0xe5,0xb1,0xba,0xe5,0xb2,0x90,0xe8,0xb9,0x8a,0xe8,0x90,0x81,0xe8,0x95,0xb2,0xe6,0xa1,0xa4,0xe6,0x86,0xa9,0xe8,0x8a,0xaa,0xe8,0x8d,0xa0,0xe8,0x90,0x8b,0xe8,0x8a,0x91,0xe6,0xb1,0x94,0xe4,0xba,0x9f,0xe9,0xb3,0x8d,0xe4,0xbf,0x9f,0xe6,0xa7,0xad,0xe5,0x98,0x81,0xe8,0x9b,0xb4,0xe7,0xb6,0xa6,0xe4,0xba,0x93,0xe6,0xac,0xb9,0xe7,0x90,0xaa,0xe9,0xba,0x92,0xe7,0x90,0xa6,0xe8,0x9c,0x9e,0xe5,0x9c,0xbb,0xe6,0x9d,0x9e,0xe8,0x91,0xba,0xe7,0xa2,0x9b,0xe6,0xb7,0x87,0xe7,0xa5,0x97,0xe8,0x80,0x86,0xe7,0xbb,0xae,0x00};

//const unsigned char PY_mb_qia   []={"恰卡掐洽袷葜髂"};
const unsigned char PY_mb_qia   []={0xe6,0x81,0xb0,0xe5,0x8d,0xa1,0xe6,0x8e,0x90,0xe6,0xb4,0xbd,0xe8,0xa2,0xb7,0xe8,0x91,0x9c,0xe9,0xab,0x82,0x00};

//const unsigned char PY_mb_qian  []={"前钱千牵浅签欠铅嵌钎迁钳乾谴谦潜歉纤扦遣黔堑仟岍钤褰箝掮搴倩慊悭愆虔芡荨缱佥芊阡肷茜椠犍骞"};
const unsigned char PY_mb_qian  []={0xe5,0x89,0x8d,0xe9,0x92,0xb1,0xe5,0x8d,0x83,0xe7,0x89,0xb5,0xe6,0xb5,0x85,0xe7,0xad,0xbe,0xe6,0xac,0xa0,0xe9,0x93,0x85,0xe5,0xb5,0x8c,0xe9,0x92,0x8e,0xe8,0xbf,0x81,0xe9,0x92,0xb3,0xe4,0xb9,0xbe,0xe8,0xb0,0xb4,0xe8,0xb0,0xa6,0xe6,0xbd,0x9c,0xe6,0xad,0x89,0xe7,0xba,0xa4,0xe6,0x89,0xa6,0xe9,0x81,0xa3,0xe9,0xbb,0x94,0xe5,0xa0,0x91,0xe4,0xbb,0x9f,0xe5,0xb2,0x8d,0xe9,0x92,0xa4,0xe8,0xa4,0xb0,0xe7,0xae,0x9d,0xe6,0x8e,0xae,0xe6,0x90,0xb4,0xe5,0x80,0xa9,0xe6,0x85,0x8a,0xe6,0x82,0xad,0xe6,0x84,0x86,0xe8,0x99,0x94,0xe8,0x8a,0xa1,0xe8,0x8d,0xa8,0xe7,0xbc,0xb1,0xe4,0xbd,0xa5,0xe8,0x8a,0x8a,0xe9,0x98,0xa1,0xe8,0x82,0xb7,0xe8,0x8c,0x9c,0xe6,0xa4,0xa0,0xe7,0x8a,0x8d,0xe9,0xaa,0x9e,0x00};

//const unsigned char PY_mb_qiang []={"强枪墙抢腔呛羌蔷将蜣跄戗襁戕炝镪锖锵羟樯嫱"};
const unsigned char PY_mb_qiang []={0xe5,0xbc,0xba,0xe6,0x9e,0xaa,0xe5,0xa2,0x99,0xe6,0x8a,0xa2,0xe8,0x85,0x94,0xe5,0x91,0x9b,0xe7,0xbe,0x8c,0xe8,0x94,0xb7,0xe5,0xb0,0x86,0xe8,0x9c,0xa3,0xe8,0xb7,0x84,0xe6,0x88,0x97,0xe8,0xa5,0x81,0xe6,0x88,0x95,0xe7,0x82,0x9d,0xe9,0x95,0xaa,0xe9,0x94,0x96,0xe9,0x94,0xb5,0xe7,0xbe,0x9f,0xe6,0xa8,0xaf,0xe5,0xab,0xb1,0x00};

//const unsigned char PY_mb_qiao  []={"桥瞧敲巧翘锹壳鞘撬悄俏窍雀乔侨峭橇樵荞跷硗憔谯鞒愀缲诮劁"};
const unsigned char PY_mb_qiao  []={0xe6,0xa1,0xa5,0xe7,0x9e,0xa7,0xe6,0x95,0xb2,0xe5,0xb7,0xa7,0xe7,0xbf,0x98,0xe9,0x94,0xb9,0xe5,0xa3,0xb3,0xe9,0x9e,0x98,0xe6,0x92,0xac,0xe6,0x82,0x84,0xe4,0xbf,0x8f,0xe7,0xaa,0x8d,0xe9,0x9b,0x80,0xe4,0xb9,0x94,0xe4,0xbe,0xa8,0xe5,0xb3,0xad,0xe6,0xa9,0x87,0xe6,0xa8,0xb5,0xe8,0x8d,0x9e,0xe8,0xb7,0xb7,0xe7,0xa1,0x97,0xe6,0x86,0x94,0xe8,0xb0,0xaf,0xe9,0x9e,0x92,0xe6,0x84,0x80,0xe7,0xbc,0xb2,0xe8,0xaf,0xae,0xe5,0x8a,0x81,0x00};

//const unsigned char PY_mb_qie   []={"切且怯窃茄砌郄趄惬锲妾箧慊伽挈"};
const unsigned char PY_mb_qie   []={0xe5,0x88,0x87,0xe4,0xb8,0x94,0xe6,0x80,0xaf,0xe7,0xaa,0x83,0xe8,0x8c,0x84,0xe7,0xa0,0x8c,0xe9,0x83,0x84,0xe8,0xb6,0x84,0xe6,0x83,0xac,0xe9,0x94,0xb2,0xe5,0xa6,0xbe,0xe7,0xae,0xa7,0xe6,0x85,0x8a,0xe4,0xbc,0xbd,0xe6,0x8c,0x88,0x00};

//const unsigned char PY_mb_qin   []={"亲琴侵勤擒寝秦芹沁禽钦吣覃矜衾芩溱廑嗪螓噙揿檎锓"};
const unsigned char PY_mb_qin   []={0xe4,0xba,0xb2,0xe7,0x90,0xb4,0xe4,0xbe,0xb5,0xe5,0x8b,0xa4,0xe6,0x93,0x92,0xe5,0xaf,0x9d,0xe7,0xa7,0xa6,0xe8,0x8a,0xb9,0xe6,0xb2,0x81,0xe7,0xa6,0xbd,0xe9,0x92,0xa6,0xe5,0x90,0xa3,0xe8,0xa6,0x83,0xe7,0x9f,0x9c,0xe8,0xa1,0xbe,0xe8,0x8a,0xa9,0xe6,0xba,0xb1,0xe5,0xbb,0x91,0xe5,0x97,0xaa,0xe8,0x9e,0x93,0xe5,0x99,0x99,0xe6,0x8f,0xbf,0xe6,0xaa,0x8e,0xe9,0x94,0x93,0x00};

//const unsigned char PY_mb_qing  []={"请轻清青情晴氢倾庆擎顷亲卿氰圊謦檠箐苘蜻黥罄鲭磬綮"};
const unsigned char PY_mb_qing  []={0xe8,0xaf,0xb7,0xe8,0xbd,0xbb,0xe6,0xb8,0x85,0xe9,0x9d,0x92,0xe6,0x83,0x85,0xe6,0x99,0xb4,0xe6,0xb0,0xa2,0xe5,0x80,0xbe,0xe5,0xba,0x86,0xe6,0x93,0x8e,0xe9,0xa1,0xb7,0xe4,0xba,0xb2,0xe5,0x8d,0xbf,0xe6,0xb0,0xb0,0xe5,0x9c,0x8a,0xe8,0xac,0xa6,0xe6,0xaa,0xa0,0xe7,0xae,0x90,0xe8,0x8b,0x98,0xe8,0x9c,0xbb,0xe9,0xbb,0xa5,0xe7,0xbd,0x84,0xe9,0xb2,0xad,0xe7,0xa3,0xac,0xe7,0xb6,0xae,0x00};

//const unsigned char PY_mb_qiong []={"穷琼跫穹邛蛩茕銎筇"};
const unsigned char PY_mb_qiong []={0xe7,0xa9,0xb7,0xe7,0x90,0xbc,0xe8,0xb7,0xab,0xe7,0xa9,0xb9,0xe9,0x82,0x9b,0xe8,0x9b,0xa9,0xe8,0x8c,0x95,0xe9,0x8a,0x8e,0xe7,0xad,0x87,0x00};

//const unsigned char PY_mb_qiu   []={"求球秋丘泅仇邱囚酋龟楸蚯裘糗蝤巯逑俅虬赇鳅犰湫鼽遒"};
const unsigned char PY_mb_qiu   []={0xe6,0xb1,0x82,0xe7,0x90,0x83,0xe7,0xa7,0x8b,0xe4,0xb8,0x98,0xe6,0xb3,0x85,0xe4,0xbb,0x87,0xe9,0x82,0xb1,0xe5,0x9b,0x9a,0xe9,0x85,0x8b,0xe9,0xbe,0x9f,0xe6,0xa5,0xb8,0xe8,0x9a,0xaf,0xe8,0xa3,0x98,0xe7,0xb3,0x97,0xe8,0x9d,0xa4,0xe5,0xb7,0xaf,0xe9,0x80,0x91,0xe4,0xbf,0x85,0xe8,0x99,0xac,0xe8,0xb5,0x87,0xe9,0xb3,0x85,0xe7,0x8a,0xb0,0xe6,0xb9,0xab,0xe9,0xbc,0xbd,0xe9,0x81,0x92,0x00};

//const unsigned char PY_mb_qu    []={"去取区娶渠曲趋趣屈驱蛆躯龋戌蠼蘧祛蕖磲劬诎鸲阒麴癯衢黢璩氍觑蛐朐瞿岖苣"};
const unsigned char PY_mb_qu    []={0xe5,0x8e,0xbb,0xe5,0x8f,0x96,0xe5,0x8c,0xba,0xe5,0xa8,0xb6,0xe6,0xb8,0xa0,0xe6,0x9b,0xb2,0xe8,0xb6,0x8b,0xe8,0xb6,0xa3,0xe5,0xb1,0x88,0xe9,0xa9,0xb1,0xe8,0x9b,0x86,0xe8,0xba,0xaf,0xe9,0xbe,0x8b,0xe6,0x88,0x8c,0xe8,0xa0,0xbc,0xe8,0x98,0xa7,0xe7,0xa5,0x9b,0xe8,0x95,0x96,0xe7,0xa3,0xb2,0xe5,0x8a,0xac,0xe8,0xaf,0x8e,0xe9,0xb8,0xb2,0xe9,0x98,0x92,0xe9,0xba,0xb4,0xe7,0x99,0xaf,0xe8,0xa1,0xa2,0xe9,0xbb,0xa2,0xe7,0x92,0xa9,0xe6,0xb0,0x8d,0xe8,0xa7,0x91,0xe8,0x9b,0x90,0xe6,0x9c,0x90,0xe7,0x9e,0xbf,0xe5,0xb2,0x96,0xe8,0x8b,0xa3,0x00};

//const unsigned char PY_mb_quan  []={"全权劝圈拳犬泉券颧痊醛铨筌绻诠辁畎鬈悛蜷荃"};
const unsigned char PY_mb_quan  []={0xe5,0x85,0xa8,0xe6,0x9d,0x83,0xe5,0x8a,0x9d,0xe5,0x9c,0x88,0xe6,0x8b,0xb3,0xe7,0x8a,0xac,0xe6,0xb3,0x89,0xe5,0x88,0xb8,0xe9,0xa2,0xa7,0xe7,0x97,0x8a,0xe9,0x86,0x9b,0xe9,0x93,0xa8,0xe7,0xad,0x8c,0xe7,0xbb,0xbb,0xe8,0xaf,0xa0,0xe8,0xbe,0x81,0xe7,0x95,0x8e,0xe9,0xac,0x88,0xe6,0x82,0x9b,0xe8,0x9c,0xb7,0xe8,0x8d,0x83,0x00};

//const unsigned char PY_mb_que   []={"却缺确雀瘸鹊炔榷阙阕悫"};
const unsigned char PY_mb_que   []={0xe5,0x8d,0xb4,0xe7,0xbc,0xba,0xe7,0xa1,0xae,0xe9,0x9b,0x80,0xe7,0x98,0xb8,0xe9,0xb9,0x8a,0xe7,0x82,0x94,0xe6,0xa6,0xb7,0xe9,0x98,0x99,0xe9,0x98,0x95,0xe6,0x82,0xab,0x00};

//const unsigned char PY_mb_qun   []={"群裙逡麇"};
const unsigned char PY_mb_qun   []={0xe7,0xbe,0xa4,0xe8,0xa3,0x99,0xe9,0x80,0xa1,0xe9,0xba,0x87,0x00};

//const unsigned char PY_mb_ran   []={"染燃然冉髯苒蚺"};
const unsigned char PY_mb_ran   []={0xe6,0x9f,0x93,0xe7,0x87,0x83,0xe7,0x84,0xb6,0xe5,0x86,0x89,0xe9,0xab,0xaf,0xe8,0x8b,0x92,0xe8,0x9a,0xba,0x00};

//const unsigned char PY_mb_rang  []={"让嚷瓤攘壤穰禳"};
const unsigned char PY_mb_rang  []={0xe8,0xae,0xa9,0xe5,0x9a,0xb7,0xe7,0x93,0xa4,0xe6,0x94,0x98,0xe5,0xa3,0xa4,0xe7,0xa9,0xb0,0xe7,0xa6,0xb3,0x00};

//const unsigned char PY_mb_rao   []={"饶绕扰荛桡娆"};
const unsigned char PY_mb_rao   []={0xe9,0xa5,0xb6,0xe7,0xbb,0x95,0xe6,0x89,0xb0,0xe8,0x8d,0x9b,0xe6,0xa1,0xa1,0xe5,0xa8,0x86,0x00};

//const unsigned char PY_mb_re    []={"热若惹喏"};
const unsigned char PY_mb_re    []={0xe7,0x83,0xad,0xe8,0x8b,0xa5,0xe6,0x83,0xb9,0xe5,0x96,0x8f,0x00};

//const unsigned char PY_mb_ren   []={"人任忍认刃仁韧妊纫壬饪轫仞荏葚衽稔"};
const unsigned char PY_mb_ren   []={0xe4,0xba,0xba,0xe4,0xbb,0xbb,0xe5,0xbf,0x8d,0xe8,0xae,0xa4,0xe5,0x88,0x83,0xe4,0xbb,0x81,0xe9,0x9f,0xa7,0xe5,0xa6,0x8a,0xe7,0xba,0xab,0xe5,0xa3,0xac,0xe9,0xa5,0xaa,0xe8,0xbd,0xab,0xe4,0xbb,0x9e,0xe8,0x8d,0x8f,0xe8,0x91,0x9a,0xe8,0xa1,0xbd,0xe7,0xa8,0x94,0x00};

//const unsigned char PY_mb_reng  []={"扔仍"};
const unsigned char PY_mb_reng  []={0xe6,0x89,0x94,0xe4,0xbb,0x8d,0x00};

//const unsigned char PY_mb_ri    []={"日"};
const unsigned char PY_mb_ri    []={0xe6,0x97,0xa5,0x00};

//const unsigned char PY_mb_rong  []={"容绒融溶熔荣戎蓉冗茸榕狨嵘肜蝾"};
const unsigned char PY_mb_rong  []={0xe5,0xae,0xb9,0xe7,0xbb,0x92,0xe8,0x9e,0x8d,0xe6,0xba,0xb6,0xe7,0x86,0x94,0xe8,0x8d,0xa3,0xe6,0x88,0x8e,0xe8,0x93,0x89,0xe5,0x86,0x97,0xe8,0x8c,0xb8,0xe6,0xa6,0x95,0xe7,0x8b,0xa8,0xe5,0xb5,0x98,0xe8,0x82,0x9c,0xe8,0x9d,0xbe,0x00};

//const unsigned char PY_mb_rou   []={"肉揉柔糅蹂鞣"};
const unsigned char PY_mb_rou   []={0xe8,0x82,0x89,0xe6,0x8f,0x89,0xe6,0x9f,0x94,0xe7,0xb3,0x85,0xe8,0xb9,0x82,0xe9,0x9e,0xa3,0x00};

//const unsigned char PY_mb_ru    []={"如入汝儒茹乳褥辱蠕孺蓐襦铷嚅缛濡薷颥溽洳"};
const unsigned char PY_mb_ru    []={0xe5,0xa6,0x82,0xe5,0x85,0xa5,0xe6,0xb1,0x9d,0xe5,0x84,0x92,0xe8,0x8c,0xb9,0xe4,0xb9,0xb3,0xe8,0xa4,0xa5,0xe8,0xbe,0xb1,0xe8,0xa0,0x95,0xe5,0xad,0xba,0xe8,0x93,0x90,0xe8,0xa5,0xa6,0xe9,0x93,0xb7,0xe5,0x9a,0x85,0xe7,0xbc,0x9b,0xe6,0xbf,0xa1,0xe8,0x96,0xb7,0xe9,0xa2,0xa5,0xe6,0xba,0xbd,0xe6,0xb4,0xb3,0x00};

//const unsigned char PY_mb_ruan  []={"软阮朊"};
const unsigned char PY_mb_ruan  []={0xe8,0xbd,0xaf,0xe9,0x98,0xae,0xe6,0x9c,0x8a,0x00};

//const unsigned char PY_mb_rui   []={"瑞蕊锐睿芮蚋枘蕤"};
const unsigned char PY_mb_rui   []={0xe7,0x91,0x9e,0xe8,0x95,0x8a,0xe9,0x94,0x90,0xe7,0x9d,0xbf,0xe8,0x8a,0xae,0xe8,0x9a,0x8b,0xe6,0x9e,0x98,0xe8,0x95,0xa4,0x00};

//const unsigned char PY_mb_run   []={"闰润"};
const unsigned char PY_mb_run   []={0xe9,0x97,0xb0,0xe6,0xb6,0xa6,0x00};

//const unsigned char PY_mb_ruo   []={"若弱偌箬"};
const unsigned char PY_mb_ruo   []={0xe8,0x8b,0xa5,0xe5,0xbc,0xb1,0xe5,0x81,0x8c,0xe7,0xae,0xac,0x00};

//const unsigned char PY_mb_sa    []={"撒洒萨挲仨卅飒脎"};
const unsigned char PY_mb_sa    []={0xe6,0x92,0x92,0xe6,0xb4,0x92,0xe8,0x90,0xa8,0xe6,0x8c,0xb2,0xe4,0xbb,0xa8,0xe5,0x8d,0x85,0xe9,0xa3,0x92,0xe8,0x84,0x8e,0x00};

//const unsigned char PY_mb_sai   []={"塞腮鳃思赛噻"};
const unsigned char PY_mb_sai   []={0xe5,0xa1,0x9e,0xe8,0x85,0xae,0xe9,0xb3,0x83,0xe6,0x80,0x9d,0xe8,0xb5,0x9b,0xe5,0x99,0xbb,0x00};

//const unsigned char PY_mb_san   []={"三散伞叁馓糁毵霰"};
const unsigned char PY_mb_san   []={0xe4,0xb8,0x89,0xe6,0x95,0xa3,0xe4,0xbc,0x9e,0xe5,0x8f,0x81,0xe9,0xa6,0x93,0xe7,0xb3,0x81,0xe6,0xaf,0xb5,0xe9,0x9c,0xb0,0x00};

//const unsigned char PY_mb_sang  []={"桑丧嗓颡磉搡"};
const unsigned char PY_mb_sang  []={0xe6,0xa1,0x91,0xe4,0xb8,0xa7,0xe5,0x97,0x93,0xe9,0xa2,0xa1,0xe7,0xa3,0x89,0xe6,0x90,0xa1,0x00};

//const unsigned char PY_mb_sao   []={"扫嫂搔骚梢埽鳋臊缫瘙"};
const unsigned char PY_mb_sao   []={0xe6,0x89,0xab,0xe5,0xab,0x82,0xe6,0x90,0x94,0xe9,0xaa,0x9a,0xe6,0xa2,0xa2,0xe5,0x9f,0xbd,0xe9,0xb3,0x8b,0xe8,0x87,0x8a,0xe7,0xbc,0xab,0xe7,0x98,0x99,0x00};

//const unsigned char PY_mb_se    []={"色涩瑟塞啬铯穑"};
const unsigned char PY_mb_se    []={0xe8,0x89,0xb2,0xe6,0xb6,0xa9,0xe7,0x91,0x9f,0xe5,0xa1,0x9e,0xe5,0x95,0xac,0xe9,0x93,0xaf,0xe7,0xa9,0x91,0x00};

//const unsigned char PY_mb_sen   []={"森"};
const unsigned char PY_mb_sen   []={0xe6,0xa3,0xae,0x00};

//const unsigned char PY_mb_seng  []={"僧"};
const unsigned char PY_mb_seng  []={0xe5,0x83,0xa7,0x00};

//const unsigned char PY_mb_sha   []={"杀沙啥纱傻砂刹莎厦煞杉嗄唼鲨霎铩痧裟挲歃"};
const unsigned char PY_mb_sha   []={0xe6,0x9d,0x80,0xe6,0xb2,0x99,0xe5,0x95,0xa5,0xe7,0xba,0xb1,0xe5,0x82,0xbb,0xe7,0xa0,0x82,0xe5,0x88,0xb9,0xe8,0x8e,0x8e,0xe5,0x8e,0xa6,0xe7,0x85,0x9e,0xe6,0x9d,0x89,0xe5,0x97,0x84,0xe5,0x94,0xbc,0xe9,0xb2,0xa8,0xe9,0x9c,0x8e,0xe9,0x93,0xa9,0xe7,0x97,0xa7,0xe8,0xa3,0x9f,0xe6,0x8c,0xb2,0xe6,0xad,0x83,0x00};

//const unsigned char PY_mb_shai  []={"晒筛色酾"};
const unsigned char PY_mb_shai  []={0xe6,0x99,0x92,0xe7,0xad,0x9b,0xe8,0x89,0xb2,0xe9,0x85,0xbe,0x00};

//const unsigned char PY_mb_shan  []={"山闪衫善扇杉删煽单珊掺赡栅苫掸膳陕汕擅缮嬗蟮芟禅跚鄯潸鳝姗剡骟疝膻讪钐舢埏"};
const unsigned char PY_mb_shan  []={0xe5,0xb1,0xb1,0xe9,0x97,0xaa,0xe8,0xa1,0xab,0xe5,0x96,0x84,0xe6,0x89,0x87,0xe6,0x9d,0x89,0xe5,0x88,0xa0,0xe7,0x85,0xbd,0xe5,0x8d,0x95,0xe7,0x8f,0x8a,0xe6,0x8e,0xba,0xe8,0xb5,0xa1,0xe6,0xa0,0x85,0xe8,0x8b,0xab,0xe6,0x8e,0xb8,0xe8,0x86,0xb3,0xe9,0x99,0x95,0xe6,0xb1,0x95,0xe6,0x93,0x85,0xe7,0xbc,0xae,0xe5,0xac,0x97,0xe8,0x9f,0xae,0xe8,0x8a,0x9f,0xe7,0xa6,0x85,0xe8,0xb7,0x9a,0xe9,0x84,0xaf,0xe6,0xbd,0xb8,0xe9,0xb3,0x9d,0xe5,0xa7,0x97,0xe5,0x89,0xa1,0xe9,0xaa,0x9f,0xe7,0x96,0x9d,0xe8,0x86,0xbb,0xe8,0xae,0xaa,0xe9,0x92,0x90,0xe8,0x88,0xa2,0xe5,0x9f,0x8f,0x00};

//const unsigned char PY_mb_shang []={"上伤尚商赏晌墒汤裳熵觞绱殇垧"};
const unsigned char PY_mb_shang []={0xe4,0xb8,0x8a,0xe4,0xbc,0xa4,0xe5,0xb0,0x9a,0xe5,0x95,0x86,0xe8,0xb5,0x8f,0xe6,0x99,0x8c,0xe5,0xa2,0x92,0xe6,0xb1,0xa4,0xe8,0xa3,0xb3,0xe7,0x86,0xb5,0xe8,0xa7,0x9e,0xe7,0xbb,0xb1,0xe6,0xae,0x87,0xe5,0x9e,0xa7,0x00};

//const unsigned char PY_mb_shao  []={"少烧捎哨勺梢稍邵韶绍芍召鞘苕劭潲艄蛸筲"};
const unsigned char PY_mb_shao  []={0xe5,0xb0,0x91,0xe7,0x83,0xa7,0xe6,0x8d,0x8e,0xe5,0x93,0xa8,0xe5,0x8b,0xba,0xe6,0xa2,0xa2,0xe7,0xa8,0x8d,0xe9,0x82,0xb5,0xe9,0x9f,0xb6,0xe7,0xbb,0x8d,0xe8,0x8a,0x8d,0xe5,0x8f,0xac,0xe9,0x9e,0x98,0xe8,0x8b,0x95,0xe5,0x8a,0xad,0xe6,0xbd,0xb2,0xe8,0x89,0x84,0xe8,0x9b,0xb8,0xe7,0xad,0xb2,0x00};

//const unsigned char PY_mb_she   []={"社射蛇设舌摄舍折涉赊赦慑奢歙厍畲猞麝滠佘"};
const unsigned char PY_mb_she   []={0xe7,0xa4,0xbe,0xe5,0xb0,0x84,0xe8,0x9b,0x87,0xe8,0xae,0xbe,0xe8,0x88,0x8c,0xe6,0x91,0x84,0xe8,0x88,0x8d,0xe6,0x8a,0x98,0xe6,0xb6,0x89,0xe8,0xb5,0x8a,0xe8,0xb5,0xa6,0xe6,0x85,0x91,0xe5,0xa5,0xa2,0xe6,0xad,0x99,0xe5,0x8e,0x8d,0xe7,0x95,0xb2,0xe7,0x8c,0x9e,0xe9,0xba,0x9d,0xe6,0xbb,0xa0,0xe4,0xbd,0x98,0x00};

//const unsigned char PY_mb_shen  []={"身伸深婶神甚渗肾审申沈绅呻参砷什娠慎葚糁莘诜谂矧椹渖蜃哂胂"};
const unsigned char PY_mb_shen  []={0xe8,0xba,0xab,0xe4,0xbc,0xb8,0xe6,0xb7,0xb1,0xe5,0xa9,0xb6,0xe7,0xa5,0x9e,0xe7,0x94,0x9a,0xe6,0xb8,0x97,0xe8,0x82,0xbe,0xe5,0xae,0xa1,0xe7,0x94,0xb3,0xe6,0xb2,0x88,0xe7,0xbb,0x85,0xe5,0x91,0xbb,0xe5,0x8f,0x82,0xe7,0xa0,0xb7,0xe4,0xbb,0x80,0xe5,0xa8,0xa0,0xe6,0x85,0x8e,0xe8,0x91,0x9a,0xe7,0xb3,0x81,0xe8,0x8e,0x98,0xe8,0xaf,0x9c,0xe8,0xb0,0x82,0xe7,0x9f,0xa7,0xe6,0xa4,0xb9,0xe6,0xb8,0x96,0xe8,0x9c,0x83,0xe5,0x93,0x82,0xe8,0x83,0x82,0x00};

//const unsigned char PY_mb_sheng []={"声省剩生升绳胜盛圣甥牲乘晟渑眚笙嵊"};
const unsigned char PY_mb_sheng []={0xe5,0xa3,0xb0,0xe7,0x9c,0x81,0xe5,0x89,0xa9,0xe7,0x94,0x9f,0xe5,0x8d,0x87,0xe7,0xbb,0xb3,0xe8,0x83,0x9c,0xe7,0x9b,0x9b,0xe5,0x9c,0xa3,0xe7,0x94,0xa5,0xe7,0x89,0xb2,0xe4,0xb9,0x98,0xe6,0x99,0x9f,0xe6,0xb8,0x91,0xe7,0x9c,0x9a,0xe7,0xac,0x99,0xe5,0xb5,0x8a,0x00};

//const unsigned char PY_mb_shi   []={"是使十时事室市石师试史式识虱矢拾屎驶始似嘘示士世柿匙拭誓逝势什殖峙嗜噬失适仕侍释饰氏狮食恃蚀视实施湿诗尸豕莳埘铈舐鲥鲺贳轼蓍筮炻谥弑酾螫"};
const unsigned char PY_mb_shi   []={0xe6,0x98,0xaf,0xe4,0xbd,0xbf,0xe5,0x8d,0x81,0xe6,0x97,0xb6,0xe4,0xba,0x8b,0xe5,0xae,0xa4,0xe5,0xb8,0x82,0xe7,0x9f,0xb3,0xe5,0xb8,0x88,0xe8,0xaf,0x95,0xe5,0x8f,0xb2,0xe5,0xbc,0x8f,0xe8,0xaf,0x86,0xe8,0x99,0xb1,0xe7,0x9f,0xa2,0xe6,0x8b,0xbe,0xe5,0xb1,0x8e,0xe9,0xa9,0xb6,0xe5,0xa7,0x8b,0xe4,0xbc,0xbc,0xe5,0x98,0x98,0xe7,0xa4,0xba,0xe5,0xa3,0xab,0xe4,0xb8,0x96,0xe6,0x9f,0xbf,0xe5,0x8c,0x99,0xe6,0x8b,0xad,0xe8,0xaa,0x93,0xe9,0x80,0x9d,0xe5,0x8a,0xbf,0xe4,0xbb,0x80,0xe6,0xae,0x96,0xe5,0xb3,0x99,0xe5,0x97,0x9c,0xe5,0x99,0xac,0xe5,0xa4,0xb1,0xe9,0x80,0x82,0xe4,0xbb,0x95,0xe4,0xbe,0x8d,0xe9,0x87,0x8a,0xe9,0xa5,0xb0,0xe6,0xb0,0x8f,0xe7,0x8b,0xae,0xe9,0xa3,0x9f,0xe6,0x81,0x83,0xe8,0x9a,0x80,0xe8,0xa7,0x86,0xe5,0xae,0x9e,0xe6,0x96,0xbd,0xe6,0xb9,0xbf,0xe8,0xaf,0x97,0xe5,0xb0,0xb8,0xe8,0xb1,0x95,0xe8,0x8e,0xb3,0xe5,0x9f,0x98,0xe9,0x93,0x88,0xe8,0x88,0x90,0xe9,0xb2,0xa5,0xe9,0xb2,0xba,0xe8,0xb4,0xb3,0xe8,0xbd,0xbc,0xe8,0x93,0x8d,0xe7,0xad,0xae,0xe7,0x82,0xbb,0xe8,0xb0,0xa5,0xe5,0xbc,0x91,0xe9,0x85,0xbe,0xe8,0x9e,0xab,0x00};

//const unsigned char PY_mb_shou  []={"手受收首守瘦授兽售熟寿艏狩绶"};
const unsigned char PY_mb_shou  []={0xe6,0x89,0x8b,0xe5,0x8f,0x97,0xe6,0x94,0xb6,0xe9,0xa6,0x96,0xe5,0xae,0x88,0xe7,0x98,0xa6,0xe6,0x8e,0x88,0xe5,0x85,0xbd,0xe5,0x94,0xae,0xe7,0x86,0x9f,0xe5,0xaf,0xbf,0xe8,0x89,0x8f,0xe7,0x8b,0xa9,0xe7,0xbb,0xb6,0x00};

//const unsigned char PY_mb_shu   []={"书树数熟输梳叔属束术述蜀黍鼠淑赎孰蔬疏戍竖墅庶薯漱恕枢暑殊抒曙署舒姝摅秫"};
const unsigned char PY_mb_shu   []={0xe4,0xb9,0xa6,0xe6,0xa0,0x91,0xe6,0x95,0xb0,0xe7,0x86,0x9f,0xe8,0xbe,0x93,0xe6,0xa2,0xb3,0xe5,0x8f,0x94,0xe5,0xb1,0x9e,0xe6,0x9d,0x9f,0xe6,0x9c,0xaf,0xe8,0xbf,0xb0,0xe8,0x9c,0x80,0xe9,0xbb,0x8d,0xe9,0xbc,0xa0,0xe6,0xb7,0x91,0xe8,0xb5,0x8e,0xe5,0xad,0xb0,0xe8,0x94,0xac,0xe7,0x96,0x8f,0xe6,0x88,0x8d,0xe7,0xab,0x96,0xe5,0xa2,0x85,0xe5,0xba,0xb6,0xe8,0x96,0xaf,0xe6,0xbc,0xb1,0xe6,0x81,0x95,0xe6,0x9e,0xa2,0xe6,0x9a,0x91,0xe6,0xae,0x8a,0xe6,0x8a,0x92,0xe6,0x9b,0x99,0xe7,0xbd,0xb2,0xe8,0x88,0x92,0xe5,0xa7,0x9d,0xe6,0x91,0x85,0xe7,0xa7,0xab,0x00};

//const unsigned char PY_mb_shua  []={"刷耍唰"};
const unsigned char PY_mb_shua  []={0xe5,0x88,0xb7,0xe8,0x80,0x8d,0xe5,0x94,0xb0,0x00};

//const unsigned char PY_mb_shuai []={"摔甩率帅衰蟀"};
const unsigned char PY_mb_shuai []={0xe6,0x91,0x94,0xe7,0x94,0xa9,0xe7,0x8e,0x87,0xe5,0xb8,0x85,0xe8,0xa1,0xb0,0xe8,0x9f,0x80,0x00};

//const unsigned char PY_mb_shuan []={"栓拴闩涮"};
const unsigned char PY_mb_shuan []={0xe6,0xa0,0x93,0xe6,0x8b,0xb4,0xe9,0x97,0xa9,0xe6,0xb6,0xae,0x00};

//const unsigned char PY_mb_shuang[]={"双霜爽泷孀"};
const unsigned char PY_mb_shuang[]={0xe5,0x8f,0x8c,0xe9,0x9c,0x9c,0xe7,0x88,0xbd,0xe6,0xb3,0xb7,0xe5,0xad,0x80,0x00};

//const unsigned char PY_mb_shui  []={"水谁睡税说"};
const unsigned char PY_mb_shui  []={0xe6,0xb0,0xb4,0xe8,0xb0,0x81,0xe7,0x9d,0xa1,0xe7,0xa8,0x8e,0xe8,0xaf,0xb4,0x00};

//const unsigned char PY_mb_shun  []={"顺吮瞬舜"};
const unsigned char PY_mb_shun  []={0xe9,0xa1,0xba,0xe5,0x90,0xae,0xe7,0x9e,0xac,0xe8,0x88,0x9c,0x00};

//const unsigned char PY_mb_shuo  []={"说数硕烁朔搠妁槊蒴铄"};
const unsigned char PY_mb_shuo  []={0xe8,0xaf,0xb4,0xe6,0x95,0xb0,0xe7,0xa1,0x95,0xe7,0x83,0x81,0xe6,0x9c,0x94,0xe6,0x90,0xa0,0xe5,0xa6,0x81,0xe6,0xa7,0x8a,0xe8,0x92,0xb4,0xe9,0x93,0x84,0x00};

//const unsigned char PY_mb_si    []={"四死丝撕似私嘶思寺司斯食伺厕肆饲嗣巳耜驷兕蛳厮汜锶泗笥咝鸶姒厶缌祀澌俟"};
const unsigned char PY_mb_si    []={0xe5,0x9b,0x9b,0xe6,0xad,0xbb,0xe4,0xb8,0x9d,0xe6,0x92,0x95,0xe4,0xbc,0xbc,0xe7,0xa7,0x81,0xe5,0x98,0xb6,0xe6,0x80,0x9d,0xe5,0xaf,0xba,0xe5,0x8f,0xb8,0xe6,0x96,0xaf,0xe9,0xa3,0x9f,0xe4,0xbc,0xba,0xe5,0x8e,0x95,0xe8,0x82,0x86,0xe9,0xa5,0xb2,0xe5,0x97,0xa3,0xe5,0xb7,0xb3,0xe8,0x80,0x9c,0xe9,0xa9,0xb7,0xe5,0x85,0x95,0xe8,0x9b,0xb3,0xe5,0x8e,0xae,0xe6,0xb1,0x9c,0xe9,0x94,0xb6,0xe6,0xb3,0x97,0xe7,0xac,0xa5,0xe5,0x92,0x9d,0xe9,0xb8,0xb6,0xe5,0xa7,0x92,0xe5,0x8e,0xb6,0xe7,0xbc,0x8c,0xe7,0xa5,0x80,0xe6,0xbe,0x8c,0xe4,0xbf,0x9f,0x00};

//const unsigned char PY_mb_song  []={"送松耸宋颂诵怂讼竦菘淞悚嵩凇崧忪"};
const unsigned char PY_mb_song  []={0xe9,0x80,0x81,0xe6,0x9d,0xbe,0xe8,0x80,0xb8,0xe5,0xae,0x8b,0xe9,0xa2,0x82,0xe8,0xaf,0xb5,0xe6,0x80,0x82,0xe8,0xae,0xbc,0xe7,0xab,0xa6,0xe8,0x8f,0x98,0xe6,0xb7,0x9e,0xe6,0x82,0x9a,0xe5,0xb5,0xa9,0xe5,0x87,0x87,0xe5,0xb4,0xa7,0xe5,0xbf,0xaa,0x00};

//const unsigned char PY_mb_sou   []={"艘搜擞嗽嗾嗖飕叟薮锼馊瞍溲螋擞"};
const unsigned char PY_mb_sou   []={0xe8,0x89,0x98,0xe6,0x90,0x9c,0xe6,0x93,0x9e,0xe5,0x97,0xbd,0xe5,0x97,0xbe,0xe5,0x97,0x96,0xe9,0xa3,0x95,0xe5,0x8f,0x9f,0xe8,0x96,0xae,0xe9,0x94,0xbc,0xe9,0xa6,0x8a,0xe7,0x9e,0x8d,0xe6,0xba,0xb2,0xe8,0x9e,0x8b,0xe6,0x93,0x9e,0x00};

//const unsigned char PY_mb_su    []={"素速诉塑宿俗苏肃粟酥缩溯僳愫簌觫稣夙嗉谡蔌涑"};
const unsigned char PY_mb_su    []={0xe7,0xb4,0xa0,0xe9,0x80,0x9f,0xe8,0xaf,0x89,0xe5,0xa1,0x91,0xe5,0xae,0xbf,0xe4,0xbf,0x97,0xe8,0x8b,0x8f,0xe8,0x82,0x83,0xe7,0xb2,0x9f,0xe9,0x85,0xa5,0xe7,0xbc,0xa9,0xe6,0xba,0xaf,0xe5,0x83,0xb3,0xe6,0x84,0xab,0xe7,0xb0,0x8c,0xe8,0xa7,0xab,0xe7,0xa8,0xa3,0xe5,0xa4,0x99,0xe5,0x97,0x89,0xe8,0xb0,0xa1,0xe8,0x94,0x8c,0xe6,0xb6,0x91,0x00};

//const unsigned char PY_mb_suan  []={"酸算蒜狻"};
const unsigned char PY_mb_suan  []={0xe9,0x85,0xb8,0xe7,0xae,0x97,0xe8,0x92,0x9c,0xe7,0x8b,0xbb,0x00};

//const unsigned char PY_mb_sui   []={"岁随碎虽穗遂尿隋髓绥隧祟眭谇濉邃燧荽睢"};
const unsigned char PY_mb_sui   []={0xe5,0xb2,0x81,0xe9,0x9a,0x8f,0xe7,0xa2,0x8e,0xe8,0x99,0xbd,0xe7,0xa9,0x97,0xe9,0x81,0x82,0xe5,0xb0,0xbf,0xe9,0x9a,0x8b,0xe9,0xab,0x93,0xe7,0xbb,0xa5,0xe9,0x9a,0xa7,0xe7,0xa5,0x9f,0xe7,0x9c,0xad,0xe8,0xb0,0x87,0xe6,0xbf,0x89,0xe9,0x82,0x83,0xe7,0x87,0xa7,0xe8,0x8d,0xbd,0xe7,0x9d,0xa2,0x00};

//const unsigned char PY_mb_sun   []={"孙损笋榫荪飧狲隼"};
const unsigned char PY_mb_sun   []={0xe5,0xad,0x99,0xe6,0x8d,0x9f,0xe7,0xac,0x8b,0xe6,0xa6,0xab,0xe8,0x8d,0xaa,0xe9,0xa3,0xa7,0xe7,0x8b,0xb2,0xe9,0x9a,0xbc,0x00};

//const unsigned char PY_mb_suo   []={"所缩锁琐索梭蓑莎唆挲睃嗍唢桫嗦娑羧"};
const unsigned char PY_mb_suo   []={0xe6,0x89,0x80,0xe7,0xbc,0xa9,0xe9,0x94,0x81,0xe7,0x90,0x90,0xe7,0xb4,0xa2,0xe6,0xa2,0xad,0xe8,0x93,0x91,0xe8,0x8e,0x8e,0xe5,0x94,0x86,0xe6,0x8c,0xb2,0xe7,0x9d,0x83,0xe5,0x97,0x8d,0xe5,0x94,0xa2,0xe6,0xa1,0xab,0xe5,0x97,0xa6,0xe5,0xa8,0x91,0xe7,0xbe,0xa7,0x00};

//const unsigned char PY_mb_ta    []={"他她它踏塔塌拓獭挞蹋溻趿鳎沓榻漯遢铊闼嗒"};
const unsigned char PY_mb_ta    []={0xe4,0xbb,0x96,0xe5,0xa5,0xb9,0xe5,0xae,0x83,0xe8,0xb8,0x8f,0xe5,0xa1,0x94,0xe5,0xa1,0x8c,0xe6,0x8b,0x93,0xe7,0x8d,0xad,0xe6,0x8c,0x9e,0xe8,0xb9,0x8b,0xe6,0xba,0xbb,0xe8,0xb6,0xbf,0xe9,0xb3,0x8e,0xe6,0xb2,0x93,0xe6,0xa6,0xbb,0xe6,0xbc,0xaf,0xe9,0x81,0xa2,0xe9,0x93,0x8a,0xe9,0x97,0xbc,0xe5,0x97,0x92,0x00};

//const unsigned char PY_mb_tai   []={"太抬台态胎苔泰酞汰炱肽跆呔鲐钛薹邰骀"};
const unsigned char PY_mb_tai   []={0xe5,0xa4,0xaa,0xe6,0x8a,0xac,0xe5,0x8f,0xb0,0xe6,0x80,0x81,0xe8,0x83,0x8e,0xe8,0x8b,0x94,0xe6,0xb3,0xb0,0xe9,0x85,0x9e,0xe6,0xb1,0xb0,0xe7,0x82,0xb1,0xe8,0x82,0xbd,0xe8,0xb7,0x86,0xe5,0x91,0x94,0xe9,0xb2,0x90,0xe9,0x92,0x9b,0xe8,0x96,0xb9,0xe9,0x82,0xb0,0xe9,0xaa,0x80,0x00};

//const unsigned char PY_mb_tan   []={"谈叹探滩弹碳摊潭贪坛痰毯坦炭瘫谭坍檀袒郯昙忐钽锬澹镡覃"};
const unsigned char PY_mb_tan   []={0xe8,0xb0,0x88,0xe5,0x8f,0xb9,0xe6,0x8e,0xa2,0xe6,0xbb,0xa9,0xe5,0xbc,0xb9,0xe7,0xa2,0xb3,0xe6,0x91,0x8a,0xe6,0xbd,0xad,0xe8,0xb4,0xaa,0xe5,0x9d,0x9b,0xe7,0x97,0xb0,0xe6,0xaf,0xaf,0xe5,0x9d,0xa6,0xe7,0x82,0xad,0xe7,0x98,0xab,0xe8,0xb0,0xad,0xe5,0x9d,0x8d,0xe6,0xaa,0x80,0xe8,0xa2,0x92,0xe9,0x83,0xaf,0xe6,0x98,0x99,0xe5,0xbf,0x90,0xe9,0x92,0xbd,0xe9,0x94,0xac,0xe6,0xbe,0xb9,0xe9,0x95,0xa1,0xe8,0xa6,0x83,0x00};

//const unsigned char PY_mb_tang  []={"躺趟堂糖汤塘烫倘淌唐搪棠膛螳樘羰醣瑭镗傥饧溏耥帑铴螗"};
const unsigned char PY_mb_tang  []={0xe8,0xba,0xba,0xe8,0xb6,0x9f,0xe5,0xa0,0x82,0xe7,0xb3,0x96,0xe6,0xb1,0xa4,0xe5,0xa1,0x98,0xe7,0x83,0xab,0xe5,0x80,0x98,0xe6,0xb7,0x8c,0xe5,0x94,0x90,0xe6,0x90,0xaa,0xe6,0xa3,0xa0,0xe8,0x86,0x9b,0xe8,0x9e,0xb3,0xe6,0xa8,0x98,0xe7,0xbe,0xb0,0xe9,0x86,0xa3,0xe7,0x91,0xad,0xe9,0x95,0x97,0xe5,0x82,0xa5,0xe9,0xa5,0xa7,0xe6,0xba,0x8f,0xe8,0x80,0xa5,0xe5,0xb8,0x91,0xe9,0x93,0xb4,0xe8,0x9e,0x97,0x00};

//const unsigned char PY_mb_tao   []={"套掏逃桃讨淘涛滔陶绦萄鼗啕洮韬饕叨焘"};
const unsigned char PY_mb_tao   []={0xe5,0xa5,0x97,0xe6,0x8e,0x8f,0xe9,0x80,0x83,0xe6,0xa1,0x83,0xe8,0xae,0xa8,0xe6,0xb7,0x98,0xe6,0xb6,0x9b,0xe6,0xbb,0x94,0xe9,0x99,0xb6,0xe7,0xbb,0xa6,0xe8,0x90,0x84,0xe9,0xbc,0x97,0xe5,0x95,0x95,0xe6,0xb4,0xae,0xe9,0x9f,0xac,0xe9,0xa5,0x95,0xe5,0x8f,0xa8,0xe7,0x84,0x98,0x00};

//const unsigned char PY_mb_te    []={"特忑慝铽忒"};
const unsigned char PY_mb_te    []={0xe7,0x89,0xb9,0xe5,0xbf,0x91,0xe6,0x85,0x9d,0xe9,0x93,0xbd,0xe5,0xbf,0x92,0x00};

//const unsigned char PY_mb_teng  []={"疼腾藤誊滕"};
const unsigned char PY_mb_teng  []={0xe7,0x96,0xbc,0xe8,0x85,0xbe,0xe8,0x97,0xa4,0xe8,0xaa,0x8a,0xe6,0xbb,0x95,0x00};

//const unsigned char PY_mb_ti    []={"提替体题踢蹄剃剔梯锑啼涕嚏惕屉醍鹈绨缇倜裼逖荑悌"};
const unsigned char PY_mb_ti    []={0xe6,0x8f,0x90,0xe6,0x9b,0xbf,0xe4,0xbd,0x93,0xe9,0xa2,0x98,0xe8,0xb8,0xa2,0xe8,0xb9,0x84,0xe5,0x89,0x83,0xe5,0x89,0x94,0xe6,0xa2,0xaf,0xe9,0x94,0x91,0xe5,0x95,0xbc,0xe6,0xb6,0x95,0xe5,0x9a,0x8f,0xe6,0x83,0x95,0xe5,0xb1,0x89,0xe9,0x86,0x8d,0xe9,0xb9,0x88,0xe7,0xbb,0xa8,0xe7,0xbc,0x87,0xe5,0x80,0x9c,0xe8,0xa3,0xbc,0xe9,0x80,0x96,0xe8,0x8d,0x91,0xe6,0x82,0x8c,0x00};

//const unsigned char PY_mb_tian  []={"天田添填甜舔恬腆佃掭钿阗忝殄畋"};
const unsigned char PY_mb_tian  []={0xe5,0xa4,0xa9,0xe7,0x94,0xb0,0xe6,0xb7,0xbb,0xe5,0xa1,0xab,0xe7,0x94,0x9c,0xe8,0x88,0x94,0xe6,0x81,0xac,0xe8,0x85,0x86,0xe4,0xbd,0x83,0xe6,0x8e,0xad,0xe9,0x92,0xbf,0xe9,0x98,0x97,0xe5,0xbf,0x9d,0xe6,0xae,0x84,0xe7,0x95,0x8b,0x00};

//const unsigned char PY_mb_tiao  []={"条跳挑调迢眺龆笤祧蜩髫佻窕鲦苕粜"};
const unsigned char PY_mb_tiao  []={0xe6,0x9d,0xa1,0xe8,0xb7,0xb3,0xe6,0x8c,0x91,0xe8,0xb0,0x83,0xe8,0xbf,0xa2,0xe7,0x9c,0xba,0xe9,0xbe,0x86,0xe7,0xac,0xa4,0xe7,0xa5,0xa7,0xe8,0x9c,0xa9,0xe9,0xab,0xab,0xe4,0xbd,0xbb,0xe7,0xaa,0x95,0xe9,0xb2,0xa6,0xe8,0x8b,0x95,0xe7,0xb2,0x9c,0x00};

//const unsigned char PY_mb_tie   []={"铁贴帖萜餮"};
const unsigned char PY_mb_tie   []={0xe9,0x93,0x81,0xe8,0xb4,0xb4,0xe5,0xb8,0x96,0xe8,0x90,0x9c,0xe9,0xa4,0xae,0x00};

//const unsigned char PY_mb_ting  []={"听停挺厅亭艇庭廷烃汀莛葶婷梃蜓霆町铤"};
const unsigned char PY_mb_ting  []={0xe5,0x90,0xac,0xe5,0x81,0x9c,0xe6,0x8c,0xba,0xe5,0x8e,0x85,0xe4,0xba,0xad,0xe8,0x89,0x87,0xe5,0xba,0xad,0xe5,0xbb,0xb7,0xe7,0x83,0x83,0xe6,0xb1,0x80,0xe8,0x8e,0x9b,0xe8,0x91,0xb6,0xe5,0xa9,0xb7,0xe6,0xa2,0x83,0xe8,0x9c,0x93,0xe9,0x9c,0x86,0xe7,0x94,0xba,0xe9,0x93,0xa4,0x00};

//const unsigned char PY_mb_tong  []={"同通痛铜桶筒捅统童彤桐瞳恫侗酮潼茼仝砼峒恸佟嗵垌"};
const unsigned char PY_mb_tong  []={0xe5,0x90,0x8c,0xe9,0x80,0x9a,0xe7,0x97,0x9b,0xe9,0x93,0x9c,0xe6,0xa1,0xb6,0xe7,0xad,0x92,0xe6,0x8d,0x85,0xe7,0xbb,0x9f,0xe7,0xab,0xa5,0xe5,0xbd,0xa4,0xe6,0xa1,0x90,0xe7,0x9e,0xb3,0xe6,0x81,0xab,0xe4,0xbe,0x97,0xe9,0x85,0xae,0xe6,0xbd,0xbc,0xe8,0x8c,0xbc,0xe4,0xbb,0x9d,0xe7,0xa0,0xbc,0xe5,0xb3,0x92,0xe6,0x81,0xb8,0xe4,0xbd,0x9f,0xe5,0x97,0xb5,0xe5,0x9e,0x8c,0x00};

//const unsigned char PY_mb_tou   []={"头偷透投钭骰"};
const unsigned char PY_mb_tou   []={0xe5,0xa4,0xb4,0xe5,0x81,0xb7,0xe9,0x80,0x8f,0xe6,0x8a,0x95,0xe9,0x92,0xad,0xe9,0xaa,0xb0,0x00};

//const unsigned char PY_mb_tu    []={"土图兔涂吐秃突徒凸途屠堍荼菟钍酴"};
const unsigned char PY_mb_tu    []={0xe5,0x9c,0x9f,0xe5,0x9b,0xbe,0xe5,0x85,0x94,0xe6,0xb6,0x82,0xe5,0x90,0x90,0xe7,0xa7,0x83,0xe7,0xaa,0x81,0xe5,0xbe,0x92,0xe5,0x87,0xb8,0xe9,0x80,0x94,0xe5,0xb1,0xa0,0xe5,0xa0,0x8d,0xe8,0x8d,0xbc,0xe8,0x8f,0x9f,0xe9,0x92,0x8d,0xe9,0x85,0xb4,0x00};

//const unsigned char PY_mb_tuan  []={"团湍疃抟彖"};
const unsigned char PY_mb_tuan  []={0xe5,0x9b,0xa2,0xe6,0xb9,0x8d,0xe7,0x96,0x83,0xe6,0x8a,0x9f,0xe5,0xbd,0x96,0x00};

//const unsigned char PY_mb_tui   []={"腿推退褪颓蜕煺忒"};
const unsigned char PY_mb_tui   []={0xe8,0x85,0xbf,0xe6,0x8e,0xa8,0xe9,0x80,0x80,0xe8,0xa4,0xaa,0xe9,0xa2,0x93,0xe8,0x9c,0x95,0xe7,0x85,0xba,0xe5,0xbf,0x92,0x00};

//const unsigned char PY_mb_tun   []={"吞屯褪臀囤氽饨暾豚"};
const unsigned char PY_mb_tun   []={0xe5,0x90,0x9e,0xe5,0xb1,0xaf,0xe8,0xa4,0xaa,0xe8,0x87,0x80,0xe5,0x9b,0xa4,0xe6,0xb0,0xbd,0xe9,0xa5,0xa8,0xe6,0x9a,0xbe,0xe8,0xb1,0x9a,0x00};

//const unsigned char PY_mb_tuo   []={"拖脱托妥驮拓驼椭唾鸵陀魄乇佗坨庹沱柝柁橐跎箨酡砣鼍"};
const unsigned char PY_mb_tuo   []={0xe6,0x8b,0x96,0xe8,0x84,0xb1,0xe6,0x89,0x98,0xe5,0xa6,0xa5,0xe9,0xa9,0xae,0xe6,0x8b,0x93,0xe9,0xa9,0xbc,0xe6,0xa4,0xad,0xe5,0x94,0xbe,0xe9,0xb8,0xb5,0xe9,0x99,0x80,0xe9,0xad,0x84,0xe4,0xb9,0x87,0xe4,0xbd,0x97,0xe5,0x9d,0xa8,0xe5,0xba,0xb9,0xe6,0xb2,0xb1,0xe6,0x9f,0x9d,0xe6,0x9f,0x81,0xe6,0xa9,0x90,0xe8,0xb7,0x8e,0xe7,0xae,0xa8,0xe9,0x85,0xa1,0xe7,0xa0,0xa3,0xe9,0xbc,0x8d,0x00};

//const unsigned char PY_mb_wa    []={"挖瓦蛙哇娃洼凹袜佤娲腽"};
const unsigned char PY_mb_wa    []={0xe6,0x8c,0x96,0xe7,0x93,0xa6,0xe8,0x9b,0x99,0xe5,0x93,0x87,0xe5,0xa8,0x83,0xe6,0xb4,0xbc,0xe5,0x87,0xb9,0xe8,0xa2,0x9c,0xe4,0xbd,0xa4,0xe5,0xa8,0xb2,0xe8,0x85,0xbd,0x00};

//const unsigned char PY_mb_wai   []={"外歪崴"};
const unsigned char PY_mb_wai   []={0xe5,0xa4,0x96,0xe6,0xad,0xaa,0xe5,0xb4,0xb4,0x00};

//const unsigned char PY_mb_wan   []={"完万晚碗玩弯挽湾丸腕宛婉烷顽豌惋娩皖蔓莞脘蜿绾芄琬纨剜畹菀"};
const unsigned char PY_mb_wan   []={0xe5,0xae,0x8c,0xe4,0xb8,0x87,0xe6,0x99,0x9a,0xe7,0xa2,0x97,0xe7,0x8e,0xa9,0xe5,0xbc,0xaf,0xe6,0x8c,0xbd,0xe6,0xb9,0xbe,0xe4,0xb8,0xb8,0xe8,0x85,0x95,0xe5,0xae,0x9b,0xe5,0xa9,0x89,0xe7,0x83,0xb7,0xe9,0xa1,0xbd,0xe8,0xb1,0x8c,0xe6,0x83,0x8b,0xe5,0xa8,0xa9,0xe7,0x9a,0x96,0xe8,0x94,0x93,0xe8,0x8e,0x9e,0xe8,0x84,0x98,0xe8,0x9c,0xbf,0xe7,0xbb,0xbe,0xe8,0x8a,0x84,0xe7,0x90,0xac,0xe7,0xba,0xa8,0xe5,0x89,0x9c,0xe7,0x95,0xb9,0xe8,0x8f,0x80,0x00};

//const unsigned char PY_mb_wang  []={"望忘王往网亡枉旺汪妄芒罔惘辋魍"};
const unsigned char PY_mb_wang  []={0xe6,0x9c,0x9b,0xe5,0xbf,0x98,0xe7,0x8e,0x8b,0xe5,0xbe,0x80,0xe7,0xbd,0x91,0xe4,0xba,0xa1,0xe6,0x9e,0x89,0xe6,0x97,0xba,0xe6,0xb1,0xaa,0xe5,0xa6,0x84,0xe8,0x8a,0x92,0xe7,0xbd,0x94,0xe6,0x83,0x98,0xe8,0xbe,0x8b,0xe9,0xad,0x8d,0x00};

//const unsigned char PY_mb_wei   []={"为位未围喂胃微味尾伪威伟卫危违委魏唯维畏惟韦巍蔚谓尉潍纬慰桅萎苇渭遗葳帏艉鲔娓逶闱隈沩玮涠帷崴隗诿洧偎猥猬嵬軎韪炜煨圩薇痿"};
const unsigned char PY_mb_wei   []={0xe4,0xb8,0xba,0xe4,0xbd,0x8d,0xe6,0x9c,0xaa,0xe5,0x9b,0xb4,0xe5,0x96,0x82,0xe8,0x83,0x83,0xe5,0xbe,0xae,0xe5,0x91,0xb3,0xe5,0xb0,0xbe,0xe4,0xbc,0xaa,0xe5,0xa8,0x81,0xe4,0xbc,0x9f,0xe5,0x8d,0xab,0xe5,0x8d,0xb1,0xe8,0xbf,0x9d,0xe5,0xa7,0x94,0xe9,0xad,0x8f,0xe5,0x94,0xaf,0xe7,0xbb,0xb4,0xe7,0x95,0x8f,0xe6,0x83,0x9f,0xe9,0x9f,0xa6,0xe5,0xb7,0x8d,0xe8,0x94,0x9a,0xe8,0xb0,0x93,0xe5,0xb0,0x89,0xe6,0xbd,0x8d,0xe7,0xba,0xac,0xe6,0x85,0xb0,0xe6,0xa1,0x85,0xe8,0x90,0x8e,0xe8,0x8b,0x87,0xe6,0xb8,0xad,0xe9,0x81,0x97,0xe8,0x91,0xb3,0xe5,0xb8,0x8f,0xe8,0x89,0x89,0xe9,0xb2,0x94,0xe5,0xa8,0x93,0xe9,0x80,0xb6,0xe9,0x97,0xb1,0xe9,0x9a,0x88,0xe6,0xb2,0xa9,0xe7,0x8e,0xae,0xe6,0xb6,0xa0,0xe5,0xb8,0xb7,0xe5,0xb4,0xb4,0xe9,0x9a,0x97,0xe8,0xaf,0xbf,0xe6,0xb4,0xa7,0xe5,0x81,0x8e,0xe7,0x8c,0xa5,0xe7,0x8c,0xac,0xe5,0xb5,0xac,0xe8,0xbb,0x8e,0xe9,0x9f,0xaa,0xe7,0x82,0x9c,0xe7,0x85,0xa8,0xe5,0x9c,0xa9,0xe8,0x96,0x87,0xe7,0x97,0xbf,0x00};

//const unsigned char PY_mb_wen   []={"问文闻稳温吻蚊纹瘟紊汶阌刎雯璺"};
const unsigned char PY_mb_wen   []={0xe9,0x97,0xae,0xe6,0x96,0x87,0xe9,0x97,0xbb,0xe7,0xa8,0xb3,0xe6,0xb8,0xa9,0xe5,0x90,0xbb,0xe8,0x9a,0x8a,0xe7,0xba,0xb9,0xe7,0x98,0x9f,0xe7,0xb4,0x8a,0xe6,0xb1,0xb6,0xe9,0x98,0x8c,0xe5,0x88,0x8e,0xe9,0x9b,0xaf,0xe7,0x92,0xba,0x00};

//const unsigned char PY_mb_weng  []={"翁嗡瓮蓊蕹"};
const unsigned char PY_mb_weng  []={0xe7,0xbf,0x81,0xe5,0x97,0xa1,0xe7,0x93,0xae,0xe8,0x93,0x8a,0xe8,0x95,0xb9,0x00};

//const unsigned char PY_mb_wo    []={"我握窝卧挝沃蜗涡斡倭幄龌肟莴喔渥硪"};
const unsigned char PY_mb_wo    []={0xe6,0x88,0x91,0xe6,0x8f,0xa1,0xe7,0xaa,0x9d,0xe5,0x8d,0xa7,0xe6,0x8c,0x9d,0xe6,0xb2,0x83,0xe8,0x9c,0x97,0xe6,0xb6,0xa1,0xe6,0x96,0xa1,0xe5,0x80,0xad,0xe5,0xb9,0x84,0xe9,0xbe,0x8c,0xe8,0x82,0x9f,0xe8,0x8e,0xb4,0xe5,0x96,0x94,0xe6,0xb8,0xa5,0xe7,0xa1,0xaa,0x00};

//const unsigned char PY_mb_wu    []={"无五屋物舞雾误捂污悟勿钨武戊务呜伍吴午吾侮乌毋恶诬芜巫晤梧坞妩蜈牾寤兀怃阢邬忤骛於鋈仵杌鹜婺迕痦芴焐唔庑鹉鼯浯圬"};
const unsigned char PY_mb_wu    []={0xe6,0x97,0xa0,0xe4,0xba,0x94,0xe5,0xb1,0x8b,0xe7,0x89,0xa9,0xe8,0x88,0x9e,0xe9,0x9b,0xbe,0xe8,0xaf,0xaf,0xe6,0x8d,0x82,0xe6,0xb1,0xa1,0xe6,0x82,0x9f,0xe5,0x8b,0xbf,0xe9,0x92,0xa8,0xe6,0xad,0xa6,0xe6,0x88,0x8a,0xe5,0x8a,0xa1,0xe5,0x91,0x9c,0xe4,0xbc,0x8d,0xe5,0x90,0xb4,0xe5,0x8d,0x88,0xe5,0x90,0xbe,0xe4,0xbe,0xae,0xe4,0xb9,0x8c,0xe6,0xaf,0x8b,0xe6,0x81,0xb6,0xe8,0xaf,0xac,0xe8,0x8a,0x9c,0xe5,0xb7,0xab,0xe6,0x99,0xa4,0xe6,0xa2,0xa7,0xe5,0x9d,0x9e,0xe5,0xa6,0xa9,0xe8,0x9c,0x88,0xe7,0x89,0xbe,0xe5,0xaf,0xa4,0xe5,0x85,0x80,0xe6,0x80,0x83,0xe9,0x98,0xa2,0xe9,0x82,0xac,0xe5,0xbf,0xa4,0xe9,0xaa,0x9b,0xe6,0x96,0xbc,0xe9,0x8b,0x88,0xe4,0xbb,0xb5,0xe6,0x9d,0x8c,0xe9,0xb9,0x9c,0xe5,0xa9,0xba,0xe8,0xbf,0x95,0xe7,0x97,0xa6,0xe8,0x8a,0xb4,0xe7,0x84,0x90,0xe5,0x94,0x94,0xe5,0xba,0x91,0xe9,0xb9,0x89,0xe9,0xbc,0xaf,0xe6,0xb5,0xaf,0xe5,0x9c,0xac,0x00};

//const unsigned char PY_mb_xi    []={"西洗细吸戏系喜席稀溪熄锡膝息袭惜习嘻夕悉矽熙希檄牺晰昔媳硒铣烯腊析隙栖汐犀蜥奚浠葸饩屣玺嬉禊兮翕穸禧僖淅蓰舾蹊醯欷皙蟋羲茜徙隰郗唏曦螅歙樨阋粞熹觋菥鼷裼舄"};
const unsigned char PY_mb_xi    []={0xe8,0xa5,0xbf,0xe6,0xb4,0x97,0xe7,0xbb,0x86,0xe5,0x90,0xb8,0xe6,0x88,0x8f,0xe7,0xb3,0xbb,0xe5,0x96,0x9c,0xe5,0xb8,0xad,0xe7,0xa8,0x80,0xe6,0xba,0xaa,0xe7,0x86,0x84,0xe9,0x94,0xa1,0xe8,0x86,0x9d,0xe6,0x81,0xaf,0xe8,0xa2,0xad,0xe6,0x83,0x9c,0xe4,0xb9,0xa0,0xe5,0x98,0xbb,0xe5,0xa4,0x95,0xe6,0x82,0x89,0xe7,0x9f,0xbd,0xe7,0x86,0x99,0xe5,0xb8,0x8c,0xe6,0xaa,0x84,0xe7,0x89,0xba,0xe6,0x99,0xb0,0xe6,0x98,0x94,0xe5,0xaa,0xb3,0xe7,0xa1,0x92,0xe9,0x93,0xa3,0xe7,0x83,0xaf,0xe8,0x85,0x8a,0xe6,0x9e,0x90,0xe9,0x9a,0x99,0xe6,0xa0,0x96,0xe6,0xb1,0x90,0xe7,0x8a,0x80,0xe8,0x9c,0xa5,0xe5,0xa5,0x9a,0xe6,0xb5,0xa0,0xe8,0x91,0xb8,0xe9,0xa5,0xa9,0xe5,0xb1,0xa3,0xe7,0x8e,0xba,0xe5,0xac,0x89,0xe7,0xa6,0x8a,0xe5,0x85,0xae,0xe7,0xbf,0x95,0xe7,0xa9,0xb8,0xe7,0xa6,0xa7,0xe5,0x83,0x96,0xe6,0xb7,0x85,0xe8,0x93,0xb0,0xe8,0x88,0xbe,0xe8,0xb9,0x8a,0xe9,0x86,0xaf,0xe6,0xac,0xb7,0xe7,0x9a,0x99,0xe8,0x9f,0x8b,0xe7,0xbe,0xb2,0xe8,0x8c,0x9c,0xe5,0xbe,0x99,0xe9,0x9a,0xb0,0xe9,0x83,0x97,0xe5,0x94,0x8f,0xe6,0x9b,0xa6,0xe8,0x9e,0x85,0xe6,0xad,0x99,0xe6,0xa8,0xa8,0xe9,0x98,0x8b,0xe7,0xb2,0x9e,0xe7,0x86,0xb9,0xe8,0xa7,0x8b,0xe8,0x8f,0xa5,0xe9,0xbc,0xb7,0xe8,0xa3,0xbc,0xe8,0x88,0x84,0x00};

//const unsigned char PY_mb_xia   []={"下吓夏峡虾瞎霞狭匣侠辖厦暇唬狎遐瑕柙硖罅黠呷"};
const unsigned char PY_mb_xia   []={0xe4,0xb8,0x8b,0xe5,0x90,0x93,0xe5,0xa4,0x8f,0xe5,0xb3,0xa1,0xe8,0x99,0xbe,0xe7,0x9e,0x8e,0xe9,0x9c,0x9e,0xe7,0x8b,0xad,0xe5,0x8c,0xa3,0xe4,0xbe,0xa0,0xe8,0xbe,0x96,0xe5,0x8e,0xa6,0xe6,0x9a,0x87,0xe5,0x94,0xac,0xe7,0x8b,0x8e,0xe9,0x81,0x90,0xe7,0x91,0x95,0xe6,0x9f,0x99,0xe7,0xa1,0x96,0xe7,0xbd,0x85,0xe9,0xbb,0xa0,0xe5,0x91,0xb7,0x00};

//const unsigned char PY_mb_xian  []={"先线县现显掀闲献嫌陷险鲜弦衔馅限咸锨仙腺贤纤宪舷涎羡铣见苋藓岘痫莶籼娴蚬猃祆冼燹跣跹酰暹氙鹇筅霰"};
const unsigned char PY_mb_xian  []={0xe5,0x85,0x88,0xe7,0xba,0xbf,0xe5,0x8e,0xbf,0xe7,0x8e,0xb0,0xe6,0x98,0xbe,0xe6,0x8e,0x80,0xe9,0x97,0xb2,0xe7,0x8c,0xae,0xe5,0xab,0x8c,0xe9,0x99,0xb7,0xe9,0x99,0xa9,0xe9,0xb2,0x9c,0xe5,0xbc,0xa6,0xe8,0xa1,0x94,0xe9,0xa6,0x85,0xe9,0x99,0x90,0xe5,0x92,0xb8,0xe9,0x94,0xa8,0xe4,0xbb,0x99,0xe8,0x85,0xba,0xe8,0xb4,0xa4,0xe7,0xba,0xa4,0xe5,0xae,0xaa,0xe8,0x88,0xb7,0xe6,0xb6,0x8e,0xe7,0xbe,0xa1,0xe9,0x93,0xa3,0xe8,0xa7,0x81,0xe8,0x8b,0x8b,0xe8,0x97,0x93,0xe5,0xb2,0x98,0xe7,0x97,0xab,0xe8,0x8e,0xb6,0xe7,0xb1,0xbc,0xe5,0xa8,0xb4,0xe8,0x9a,0xac,0xe7,0x8c,0x83,0xe7,0xa5,0x86,0xe5,0x86,0xbc,0xe7,0x87,0xb9,0xe8,0xb7,0xa3,0xe8,0xb7,0xb9,0xe9,0x85,0xb0,0xe6,0x9a,0xb9,0xe6,0xb0,0x99,0xe9,0xb9,0x87,0xe7,0xad,0x85,0xe9,0x9c,0xb0,0x00};

//const unsigned char PY_mb_xiang []={"想向象项响香乡相像箱巷享镶厢降翔祥橡详湘襄芗葙饷庠骧缃蟓鲞飨"};
const unsigned char PY_mb_xiang []={0xe6,0x83,0xb3,0xe5,0x90,0x91,0xe8,0xb1,0xa1,0xe9,0xa1,0xb9,0xe5,0x93,0x8d,0xe9,0xa6,0x99,0xe4,0xb9,0xa1,0xe7,0x9b,0xb8,0xe5,0x83,0x8f,0xe7,0xae,0xb1,0xe5,0xb7,0xb7,0xe4,0xba,0xab,0xe9,0x95,0xb6,0xe5,0x8e,0xa2,0xe9,0x99,0x8d,0xe7,0xbf,0x94,0xe7,0xa5,0xa5,0xe6,0xa9,0xa1,0xe8,0xaf,0xa6,0xe6,0xb9,0x98,0xe8,0xa5,0x84,0xe8,0x8a,0x97,0xe8,0x91,0x99,0xe9,0xa5,0xb7,0xe5,0xba,0xa0,0xe9,0xaa,0xa7,0xe7,0xbc,0x83,0xe8,0x9f,0x93,0xe9,0xb2,0x9e,0xe9,0xa3,0xa8,0x00};

//const unsigned char PY_mb_xiao  []={"小笑消削销萧效宵晓肖孝硝啸霄哮嚣校骁哓潇逍枭绡淆崤箫枵筱魈蛸"};
const unsigned char PY_mb_xiao  []={0xe5,0xb0,0x8f,0xe7,0xac,0x91,0xe6,0xb6,0x88,0xe5,0x89,0x8a,0xe9,0x94,0x80,0xe8,0x90,0xa7,0xe6,0x95,0x88,0xe5,0xae,0xb5,0xe6,0x99,0x93,0xe8,0x82,0x96,0xe5,0xad,0x9d,0xe7,0xa1,0x9d,0xe5,0x95,0xb8,0xe9,0x9c,0x84,0xe5,0x93,0xae,0xe5,0x9a,0xa3,0xe6,0xa0,0xa1,0xe9,0xaa,0x81,0xe5,0x93,0x93,0xe6,0xbd,0x87,0xe9,0x80,0x8d,0xe6,0x9e,0xad,0xe7,0xbb,0xa1,0xe6,0xb7,0x86,0xe5,0xb4,0xa4,0xe7,0xae,0xab,0xe6,0x9e,0xb5,0xe7,0xad,0xb1,0xe9,0xad,0x88,0xe8,0x9b,0xb8,0x00};

//const unsigned char PY_mb_xie   []={"写些鞋歇斜血谢卸挟屑蟹泻懈泄楔邪协械谐蝎携胁解契叶绁颉缬獬榭廨撷偕瀣渫亵榍邂薤躞燮勰"};
const unsigned char PY_mb_xie   []={0xe5,0x86,0x99,0xe4,0xba,0x9b,0xe9,0x9e,0x8b,0xe6,0xad,0x87,0xe6,0x96,0x9c,0xe8,0xa1,0x80,0xe8,0xb0,0xa2,0xe5,0x8d,0xb8,0xe6,0x8c,0x9f,0xe5,0xb1,0x91,0xe8,0x9f,0xb9,0xe6,0xb3,0xbb,0xe6,0x87,0x88,0xe6,0xb3,0x84,0xe6,0xa5,0x94,0xe9,0x82,0xaa,0xe5,0x8d,0x8f,0xe6,0xa2,0xb0,0xe8,0xb0,0x90,0xe8,0x9d,0x8e,0xe6,0x90,0xba,0xe8,0x83,0x81,0xe8,0xa7,0xa3,0xe5,0xa5,0x91,0xe5,0x8f,0xb6,0xe7,0xbb,0x81,0xe9,0xa2,0x89,0xe7,0xbc,0xac,0xe7,0x8d,0xac,0xe6,0xa6,0xad,0xe5,0xbb,0xa8,0xe6,0x92,0xb7,0xe5,0x81,0x95,0xe7,0x80,0xa3,0xe6,0xb8,0xab,0xe4,0xba,0xb5,0xe6,0xa6,0x8d,0xe9,0x82,0x82,0xe8,0x96,0xa4,0xe8,0xba,0x9e,0xe7,0x87,0xae,0xe5,0x8b,0xb0,0x00};

//const unsigned char PY_mb_xin   []={"新心欣信芯薪锌辛寻衅忻歆囟莘馨鑫昕镡"};
const unsigned char PY_mb_xin   []={0xe6,0x96,0xb0,0xe5,0xbf,0x83,0xe6,0xac,0xa3,0xe4,0xbf,0xa1,0xe8,0x8a,0xaf,0xe8,0x96,0xaa,0xe9,0x94,0x8c,0xe8,0xbe,0x9b,0xe5,0xaf,0xbb,0xe8,0xa1,0x85,0xe5,0xbf,0xbb,0xe6,0xad,0x86,0xe5,0x9b,0x9f,0xe8,0x8e,0x98,0xe9,0xa6,0xa8,0xe9,0x91,0xab,0xe6,0x98,0x95,0xe9,0x95,0xa1,0x00};

//const unsigned char PY_mb_xing  []={"性行型形星醒姓腥刑杏兴幸邢猩惺省硎悻荥陉擤荇"};
const unsigned char PY_mb_xing  []={0xe6,0x80,0xa7,0xe8,0xa1,0x8c,0xe5,0x9e,0x8b,0xe5,0xbd,0xa2,0xe6,0x98,0x9f,0xe9,0x86,0x92,0xe5,0xa7,0x93,0xe8,0x85,0xa5,0xe5,0x88,0x91,0xe6,0x9d,0x8f,0xe5,0x85,0xb4,0xe5,0xb9,0xb8,0xe9,0x82,0xa2,0xe7,0x8c,0xa9,0xe6,0x83,0xba,0xe7,0x9c,0x81,0xe7,0xa1,0x8e,0xe6,0x82,0xbb,0xe8,0x8d,0xa5,0xe9,0x99,0x89,0xe6,0x93,0xa4,0xe8,0x8d,0x87,0x00};

//const unsigned char PY_mb_xiong []={"胸雄凶兄熊汹匈芎"};
const unsigned char PY_mb_xiong []={0xe8,0x83,0xb8,0xe9,0x9b,0x84,0xe5,0x87,0xb6,0xe5,0x85,0x84,0xe7,0x86,0x8a,0xe6,0xb1,0xb9,0xe5,0x8c,0x88,0xe8,0x8a,0x8e,0x00};

//const unsigned char PY_mb_xiu   []={"修锈绣休羞宿嗅袖秀朽臭咻岫馐庥溴鸺貅髹"};
const unsigned char PY_mb_xiu   []={0xe4,0xbf,0xae,0xe9,0x94,0x88,0xe7,0xbb,0xa3,0xe4,0xbc,0x91,0xe7,0xbe,0x9e,0xe5,0xae,0xbf,0xe5,0x97,0x85,0xe8,0xa2,0x96,0xe7,0xa7,0x80,0xe6,0x9c,0xbd,0xe8,0x87,0xad,0xe5,0x92,0xbb,0xe5,0xb2,0xab,0xe9,0xa6,0x90,0xe5,0xba,0xa5,0xe6,0xba,0xb4,0xe9,0xb8,0xba,0xe8,0xb2,0x85,0xe9,0xab,0xb9,0x00};

//const unsigned char PY_mb_xu    []={"许须需虚嘘蓄续序叙畜絮婿戌徐旭绪吁酗恤墟糈勖栩浒蓿顼圩洫胥醑诩溆煦盱砉"};
const unsigned char PY_mb_xu    []={0xe8,0xae,0xb8,0xe9,0xa1,0xbb,0xe9,0x9c,0x80,0xe8,0x99,0x9a,0xe5,0x98,0x98,0xe8,0x93,0x84,0xe7,0xbb,0xad,0xe5,0xba,0x8f,0xe5,0x8f,0x99,0xe7,0x95,0x9c,0xe7,0xb5,0xae,0xe5,0xa9,0xbf,0xe6,0x88,0x8c,0xe5,0xbe,0x90,0xe6,0x97,0xad,0xe7,0xbb,0xaa,0xe5,0x90,0x81,0xe9,0x85,0x97,0xe6,0x81,0xa4,0xe5,0xa2,0x9f,0xe7,0xb3,0x88,0xe5,0x8b,0x96,0xe6,0xa0,0xa9,0xe6,0xb5,0x92,0xe8,0x93,0xbf,0xe9,0xa1,0xbc,0xe5,0x9c,0xa9,0xe6,0xb4,0xab,0xe8,0x83,0xa5,0xe9,0x86,0x91,0xe8,0xaf,0xa9,0xe6,0xba,0x86,0xe7,0x85,0xa6,0xe7,0x9b,0xb1,0xe7,0xa0,0x89,0x00};

//const unsigned char PY_mb_xuan  []={"选悬旋玄宣喧轩绚眩癣券儇炫谖萱揎泫渲漩璇楦暄煊碹铉镟痃"};
const unsigned char PY_mb_xuan  []={0xe9,0x80,0x89,0xe6,0x82,0xac,0xe6,0x97,0x8b,0xe7,0x8e,0x84,0xe5,0xae,0xa3,0xe5,0x96,0xa7,0xe8,0xbd,0xa9,0xe7,0xbb,0x9a,0xe7,0x9c,0xa9,0xe7,0x99,0xa3,0xe5,0x88,0xb8,0xe5,0x84,0x87,0xe7,0x82,0xab,0xe8,0xb0,0x96,0xe8,0x90,0xb1,0xe6,0x8f,0x8e,0xe6,0xb3,0xab,0xe6,0xb8,0xb2,0xe6,0xbc,0xa9,0xe7,0x92,0x87,0xe6,0xa5,0xa6,0xe6,0x9a,0x84,0xe7,0x85,0x8a,0xe7,0xa2,0xb9,0xe9,0x93,0x89,0xe9,0x95,0x9f,0xe7,0x97,0x83,0x00};

//const unsigned char PY_mb_xue   []={"学雪血靴穴削薛踅噱鳕泶"};
const unsigned char PY_mb_xue   []={0xe5,0xad,0xa6,0xe9,0x9b,0xaa,0xe8,0xa1,0x80,0xe9,0x9d,0xb4,0xe7,0xa9,0xb4,0xe5,0x89,0x8a,0xe8,0x96,0x9b,0xe8,0xb8,0x85,0xe5,0x99,0xb1,0xe9,0xb3,0x95,0xe6,0xb3,0xb6,0x00};

//const unsigned char PY_mb_xun   []={"寻讯熏训循殉旬巡迅驯汛逊勋荤询浚巽埙荀蕈薰峋徇獯恂洵浔曛醺鲟郇窨"};
const unsigned char PY_mb_xun   []={0xe5,0xaf,0xbb,0xe8,0xae,0xaf,0xe7,0x86,0x8f,0xe8,0xae,0xad,0xe5,0xbe,0xaa,0xe6,0xae,0x89,0xe6,0x97,0xac,0xe5,0xb7,0xa1,0xe8,0xbf,0x85,0xe9,0xa9,0xaf,0xe6,0xb1,0x9b,0xe9,0x80,0x8a,0xe5,0x8b,0x8b,0xe8,0x8d,0xa4,0xe8,0xaf,0xa2,0xe6,0xb5,0x9a,0xe5,0xb7,0xbd,0xe5,0x9f,0x99,0xe8,0x8d,0x80,0xe8,0x95,0x88,0xe8,0x96,0xb0,0xe5,0xb3,0x8b,0xe5,0xbe,0x87,0xe7,0x8d,0xaf,0xe6,0x81,0x82,0xe6,0xb4,0xb5,0xe6,0xb5,0x94,0xe6,0x9b,0x9b,0xe9,0x86,0xba,0xe9,0xb2,0x9f,0xe9,0x83,0x87,0xe7,0xaa,0xa8,0x00};

//const unsigned char PY_mb_ya    []={"呀压牙押芽鸭轧崖哑亚涯丫雅衙鸦讶蚜伢垭揠岈迓娅琊桠氩砑睚痖疋"};
const unsigned char PY_mb_ya    []={0xe5,0x91,0x80,0xe5,0x8e,0x8b,0xe7,0x89,0x99,0xe6,0x8a,0xbc,0xe8,0x8a,0xbd,0xe9,0xb8,0xad,0xe8,0xbd,0xa7,0xe5,0xb4,0x96,0xe5,0x93,0x91,0xe4,0xba,0x9a,0xe6,0xb6,0xaf,0xe4,0xb8,0xab,0xe9,0x9b,0x85,0xe8,0xa1,0x99,0xe9,0xb8,0xa6,0xe8,0xae,0xb6,0xe8,0x9a,0x9c,0xe4,0xbc,0xa2,0xe5,0x9e,0xad,0xe6,0x8f,0xa0,0xe5,0xb2,0x88,0xe8,0xbf,0x93,0xe5,0xa8,0x85,0xe7,0x90,0x8a,0xe6,0xa1,0xa0,0xe6,0xb0,0xa9,0xe7,0xa0,0x91,0xe7,0x9d,0x9a,0xe7,0x97,0x96,0xe7,0x96,0x8b,0x00};

//const unsigned char PY_mb_yan   []={"眼烟沿盐言演严咽淹炎掩厌宴岩研延堰验艳阉砚雁唁彦焰蜒衍谚燕颜阎焉奄厣菸魇琰滟焱筵赝兖恹檐湮谳偃胭晏闫俨郾鄢妍崦嫣罨酽餍鼹铅殷阽芫阏腌剡"};
const unsigned char PY_mb_yan   []={0xe7,0x9c,0xbc,0xe7,0x83,0x9f,0xe6,0xb2,0xbf,0xe7,0x9b,0x90,0xe8,0xa8,0x80,0xe6,0xbc,0x94,0xe4,0xb8,0xa5,0xe5,0x92,0xbd,0xe6,0xb7,0xb9,0xe7,0x82,0x8e,0xe6,0x8e,0xa9,0xe5,0x8e,0x8c,0xe5,0xae,0xb4,0xe5,0xb2,0xa9,0xe7,0xa0,0x94,0xe5,0xbb,0xb6,0xe5,0xa0,0xb0,0xe9,0xaa,0x8c,0xe8,0x89,0xb3,0xe9,0x98,0x89,0xe7,0xa0,0x9a,0xe9,0x9b,0x81,0xe5,0x94,0x81,0xe5,0xbd,0xa6,0xe7,0x84,0xb0,0xe8,0x9c,0x92,0xe8,0xa1,0x8d,0xe8,0xb0,0x9a,0xe7,0x87,0x95,0xe9,0xa2,0x9c,0xe9,0x98,0x8e,0xe7,0x84,0x89,0xe5,0xa5,0x84,0xe5,0x8e,0xa3,0xe8,0x8f,0xb8,0xe9,0xad,0x87,0xe7,0x90,0xb0,0xe6,0xbb,0x9f,0xe7,0x84,0xb1,0xe7,0xad,0xb5,0xe8,0xb5,0x9d,0xe5,0x85,0x96,0xe6,0x81,0xb9,0xe6,0xaa,0x90,0xe6,0xb9,0xae,0xe8,0xb0,0xb3,0xe5,0x81,0x83,0xe8,0x83,0xad,0xe6,0x99,0x8f,0xe9,0x97,0xab,0xe4,0xbf,0xa8,0xe9,0x83,0xbe,0xe9,0x84,0xa2,0xe5,0xa6,0x8d,0xe5,0xb4,0xa6,0xe5,0xab,0xa3,0xe7,0xbd,0xa8,0xe9,0x85,0xbd,0xe9,0xa4,0x8d,0xe9,0xbc,0xb9,0xe9,0x93,0x85,0xe6,0xae,0xb7,0xe9,0x98,0xbd,0xe8,0x8a,0xab,0xe9,0x98,0x8f,0xe8,0x85,0x8c,0xe5,0x89,0xa1,0x00};

//const unsigned char PY_mb_yang  []={"样养羊洋仰扬秧氧痒杨漾阳殃央鸯佯疡炀恙徉鞅泱蛘烊怏"};
const unsigned char PY_mb_yang  []={0xe6,0xa0,0xb7,0xe5,0x85,0xbb,0xe7,0xbe,0x8a,0xe6,0xb4,0x8b,0xe4,0xbb,0xb0,0xe6,0x89,0xac,0xe7,0xa7,0xa7,0xe6,0xb0,0xa7,0xe7,0x97,0x92,0xe6,0x9d,0xa8,0xe6,0xbc,0xbe,0xe9,0x98,0xb3,0xe6,0xae,0x83,0xe5,0xa4,0xae,0xe9,0xb8,0xaf,0xe4,0xbd,0xaf,0xe7,0x96,0xa1,0xe7,0x82,0x80,0xe6,0x81,0x99,0xe5,0xbe,0x89,0xe9,0x9e,0x85,0xe6,0xb3,0xb1,0xe8,0x9b,0x98,0xe7,0x83,0x8a,0xe6,0x80,0x8f,0x00};

//const unsigned char PY_mb_yao   []={"要摇药咬腰窑舀邀妖谣遥姚瑶耀尧钥侥夭爻吆崾徭幺珧杳轺曜肴鹞窈鳐疟陶约铫"};
const unsigned char PY_mb_yao   []={0xe8,0xa6,0x81,0xe6,0x91,0x87,0xe8,0x8d,0xaf,0xe5,0x92,0xac,0xe8,0x85,0xb0,0xe7,0xaa,0x91,0xe8,0x88,0x80,0xe9,0x82,0x80,0xe5,0xa6,0x96,0xe8,0xb0,0xa3,0xe9,0x81,0xa5,0xe5,0xa7,0x9a,0xe7,0x91,0xb6,0xe8,0x80,0x80,0xe5,0xb0,0xa7,0xe9,0x92,0xa5,0xe4,0xbe,0xa5,0xe5,0xa4,0xad,0xe7,0x88,0xbb,0xe5,0x90,0x86,0xe5,0xb4,0xbe,0xe5,0xbe,0xad,0xe5,0xb9,0xba,0xe7,0x8f,0xa7,0xe6,0x9d,0xb3,0xe8,0xbd,0xba,0xe6,0x9b,0x9c,0xe8,0x82,0xb4,0xe9,0xb9,0x9e,0xe7,0xaa,0x88,0xe9,0xb3,0x90,0xe7,0x96,0x9f,0xe9,0x99,0xb6,0xe7,0xba,0xa6,0xe9,0x93,0xab,0x00};

//const unsigned char PY_mb_ye    []={"也夜业野叶爷页液掖腋冶噎耶咽曳椰邪谒邺晔烨揶铘靥"};
const unsigned char PY_mb_ye    []={0xe4,0xb9,0x9f,0xe5,0xa4,0x9c,0xe4,0xb8,0x9a,0xe9,0x87,0x8e,0xe5,0x8f,0xb6,0xe7,0x88,0xb7,0xe9,0xa1,0xb5,0xe6,0xb6,0xb2,0xe6,0x8e,0x96,0xe8,0x85,0x8b,0xe5,0x86,0xb6,0xe5,0x99,0x8e,0xe8,0x80,0xb6,0xe5,0x92,0xbd,0xe6,0x9b,0xb3,0xe6,0xa4,0xb0,0xe9,0x82,0xaa,0xe8,0xb0,0x92,0xe9,0x82,0xba,0xe6,0x99,0x94,0xe7,0x83,0xa8,0xe6,0x8f,0xb6,0xe9,0x93,0x98,0xe9,0x9d,0xa5,0x00};

//const unsigned char PY_mb_yi    []={"一以已亿衣移依易医乙仪亦椅益倚姨翼译伊蛇遗食艾胰疑沂宜异彝壹蚁谊揖铱矣翌艺抑绎邑蛾屹尾役臆逸肄疫颐裔意毅忆义夷溢诣议怿痍镒癔怡驿旖熠酏翊欹峄圯殪嗌咦懿噫劓诒饴漪佚咿瘗猗眙羿弈苡荑仡佾贻钇缢迤刈悒黟翳弋奕蜴埸挹嶷薏呓轶镱"};
const unsigned char PY_mb_yi    []={0xe4,0xb8,0x80,0xe4,0xbb,0xa5,0xe5,0xb7,0xb2,0xe4,0xba,0xbf,0xe8,0xa1,0xa3,0xe7,0xa7,0xbb,0xe4,0xbe,0x9d,0xe6,0x98,0x93,0xe5,0x8c,0xbb,0xe4,0xb9,0x99,0xe4,0xbb,0xaa,0xe4,0xba,0xa6,0xe6,0xa4,0x85,0xe7,0x9b,0x8a,0xe5,0x80,0x9a,0xe5,0xa7,0xa8,0xe7,0xbf,0xbc,0xe8,0xaf,0x91,0xe4,0xbc,0x8a,0xe8,0x9b,0x87,0xe9,0x81,0x97,0xe9,0xa3,0x9f,0xe8,0x89,0xbe,0xe8,0x83,0xb0,0xe7,0x96,0x91,0xe6,0xb2,0x82,0xe5,0xae,0x9c,0xe5,0xbc,0x82,0xe5,0xbd,0x9d,0xe5,0xa3,0xb9,0xe8,0x9a,0x81,0xe8,0xb0,0x8a,0xe6,0x8f,0x96,0xe9,0x93,0xb1,0xe7,0x9f,0xa3,0xe7,0xbf,0x8c,0xe8,0x89,0xba,0xe6,0x8a,0x91,0xe7,0xbb,0x8e,0xe9,0x82,0x91,0xe8,0x9b,0xbe,0xe5,0xb1,0xb9,0xe5,0xb0,0xbe,0xe5,0xbd,0xb9,0xe8,0x87,0x86,0xe9,0x80,0xb8,0xe8,0x82,0x84,0xe7,0x96,0xab,0xe9,0xa2,0x90,0xe8,0xa3,0x94,0xe6,0x84,0x8f,0xe6,0xaf,0x85,0xe5,0xbf,0x86,0xe4,0xb9,0x89,0xe5,0xa4,0xb7,0xe6,0xba,0xa2,0xe8,0xaf,0xa3,0xe8,0xae,0xae,0xe6,0x80,0xbf,0xe7,0x97,0x8d,0xe9,0x95,0x92,0xe7,0x99,0x94,0xe6,0x80,0xa1,0xe9,0xa9,0xbf,0xe6,0x97,0x96,0xe7,0x86,0xa0,0xe9,0x85,0x8f,0xe7,0xbf,0x8a,0xe6,0xac,0xb9,0xe5,0xb3,0x84,0xe5,0x9c,0xaf,0xe6,0xae,0xaa,0xe5,0x97,0x8c,0xe5,0x92,0xa6,0xe6,0x87,0xbf,0xe5,0x99,0xab,0xe5,0x8a,0x93,0xe8,0xaf,0x92,0xe9,0xa5,0xb4,0xe6,0xbc,0xaa,0xe4,0xbd,0x9a,0xe5,0x92,0xbf,0xe7,0x98,0x97,0xe7,0x8c,0x97,0xe7,0x9c,0x99,0xe7,0xbe,0xbf,0xe5,0xbc,0x88,0xe8,0x8b,0xa1,0xe8,0x8d,0x91,0xe4,0xbb,0xa1,0xe4,0xbd,0xbe,0xe8,0xb4,0xbb,0xe9,0x92,0x87,0xe7,0xbc,0xa2,0xe8,0xbf,0xa4,0xe5,0x88,0x88,0xe6,0x82,0x92,0xe9,0xbb,0x9f,0xe7,0xbf,0xb3,0xe5,0xbc,0x8b,0xe5,0xa5,0x95,0xe8,0x9c,0xb4,0xe5,0x9f,0xb8,0xe6,0x8c,0xb9,0xe5,0xb6,0xb7,0xe8,0x96,0x8f,0xe5,0x91,0x93,0xe8,0xbd,0xb6,0xe9,0x95,0xb1,0x00};

//const unsigned char PY_mb_yin   []={"因引印银音饮阴隐荫吟尹寅茵淫殷姻烟堙鄞喑夤胤龈吲圻狺垠霪蚓氤铟窨瘾洇茚"};
const unsigned char PY_mb_yin   []={0xe5,0x9b,0xa0,0xe5,0xbc,0x95,0xe5,0x8d,0xb0,0xe9,0x93,0xb6,0xe9,0x9f,0xb3,0xe9,0xa5,0xae,0xe9,0x98,0xb4,0xe9,0x9a,0x90,0xe8,0x8d,0xab,0xe5,0x90,0x9f,0xe5,0xb0,0xb9,0xe5,0xaf,0x85,0xe8,0x8c,0xb5,0xe6,0xb7,0xab,0xe6,0xae,0xb7,0xe5,0xa7,0xbb,0xe7,0x83,0x9f,0xe5,0xa0,0x99,0xe9,0x84,0x9e,0xe5,0x96,0x91,0xe5,0xa4,0xa4,0xe8,0x83,0xa4,0xe9,0xbe,0x88,0xe5,0x90,0xb2,0xe5,0x9c,0xbb,0xe7,0x8b,0xba,0xe5,0x9e,0xa0,0xe9,0x9c,0xaa,0xe8,0x9a,0x93,0xe6,0xb0,0xa4,0xe9,0x93,0x9f,0xe7,0xaa,0xa8,0xe7,0x98,0xbe,0xe6,0xb4,0x87,0xe8,0x8c,0x9a,0x00};

//const unsigned char PY_mb_ying  []={"应硬影营迎映蝇赢鹰英颖莹盈婴樱缨荧萤萦楹蓥瘿茔鹦媵莺璎郢嘤撄瑛滢潆嬴罂瀛膺荥颍"};
const unsigned char PY_mb_ying  []={0xe5,0xba,0x94,0xe7,0xa1,0xac,0xe5,0xbd,0xb1,0xe8,0x90,0xa5,0xe8,0xbf,0x8e,0xe6,0x98,0xa0,0xe8,0x9d,0x87,0xe8,0xb5,0xa2,0xe9,0xb9,0xb0,0xe8,0x8b,0xb1,0xe9,0xa2,0x96,0xe8,0x8e,0xb9,0xe7,0x9b,0x88,0xe5,0xa9,0xb4,0xe6,0xa8,0xb1,0xe7,0xbc,0xa8,0xe8,0x8d,0xa7,0xe8,0x90,0xa4,0xe8,0x90,0xa6,0xe6,0xa5,0xb9,0xe8,0x93,0xa5,0xe7,0x98,0xbf,0xe8,0x8c,0x94,0xe9,0xb9,0xa6,0xe5,0xaa,0xb5,0xe8,0x8e,0xba,0xe7,0x92,0x8e,0xe9,0x83,0xa2,0xe5,0x98,0xa4,0xe6,0x92,0x84,0xe7,0x91,0x9b,0xe6,0xbb,0xa2,0xe6,0xbd,0x86,0xe5,0xac,0xb4,0xe7,0xbd,0x82,0xe7,0x80,0x9b,0xe8,0x86,0xba,0xe8,0x8d,0xa5,0xe9,0xa2,0x8d,0x00};

//const unsigned char PY_mb_yo    []={"哟育唷"};
const unsigned char PY_mb_yo    []={0xe5,0x93,0x9f,0xe8,0x82,0xb2,0xe5,0x94,0xb7,0x00};

//const unsigned char PY_mb_yong  []={"用涌永拥蛹勇雍咏泳佣踊痈庸臃恿俑壅墉喁慵邕镛甬鳙饔"};
const unsigned char PY_mb_yong  []={0xe7,0x94,0xa8,0xe6,0xb6,0x8c,0xe6,0xb0,0xb8,0xe6,0x8b,0xa5,0xe8,0x9b,0xb9,0xe5,0x8b,0x87,0xe9,0x9b,0x8d,0xe5,0x92,0x8f,0xe6,0xb3,0xb3,0xe4,0xbd,0xa3,0xe8,0xb8,0x8a,0xe7,0x97,0x88,0xe5,0xba,0xb8,0xe8,0x87,0x83,0xe6,0x81,0xbf,0xe4,0xbf,0x91,0xe5,0xa3,0x85,0xe5,0xa2,0x89,0xe5,0x96,0x81,0xe6,0x85,0xb5,0xe9,0x82,0x95,0xe9,0x95,0x9b,0xe7,0x94,0xac,0xe9,0xb3,0x99,0xe9,0xa5,0x94,0x00};

//const unsigned char PY_mb_you   []={"有又由右油游幼优友铀忧尤犹诱悠邮酉佑幽釉攸卣侑莠莜莸呦囿宥柚猷牖铕疣蚰蚴蝣鱿黝鼬蝤繇"};
const unsigned char PY_mb_you   []={0xe6,0x9c,0x89,0xe5,0x8f,0x88,0xe7,0x94,0xb1,0xe5,0x8f,0xb3,0xe6,0xb2,0xb9,0xe6,0xb8,0xb8,0xe5,0xb9,0xbc,0xe4,0xbc,0x98,0xe5,0x8f,0x8b,0xe9,0x93,0x80,0xe5,0xbf,0xa7,0xe5,0xb0,0xa4,0xe7,0x8a,0xb9,0xe8,0xaf,0xb1,0xe6,0x82,0xa0,0xe9,0x82,0xae,0xe9,0x85,0x89,0xe4,0xbd,0x91,0xe5,0xb9,0xbd,0xe9,0x87,0x89,0xe6,0x94,0xb8,0xe5,0x8d,0xa3,0xe4,0xbe,0x91,0xe8,0x8e,0xa0,0xe8,0x8e,0x9c,0xe8,0x8e,0xb8,0xe5,0x91,0xa6,0xe5,0x9b,0xbf,0xe5,0xae,0xa5,0xe6,0x9f,0x9a,0xe7,0x8c,0xb7,0xe7,0x89,0x96,0xe9,0x93,0x95,0xe7,0x96,0xa3,0xe8,0x9a,0xb0,0xe8,0x9a,0xb4,0xe8,0x9d,0xa3,0xe9,0xb1,0xbf,0xe9,0xbb,0x9d,0xe9,0xbc,0xac,0xe8,0x9d,0xa4,0xe7,0xb9,0x87,0x00};

//const unsigned char PY_mb_yu    []={"与于欲鱼雨余遇语愈狱玉渔予誉育愚羽虞娱淤舆屿禹宇迂俞逾域芋郁谷吁盂喻峪御愉粥渝尉榆隅浴寓裕预豫驭蔚妪嵛雩馀阈窬鹆妤揄窳觎臾舁龉蓣煜钰谀纡於竽瑜禺聿欤俣伛圄鹬庾昱萸瘐谕鬻圉瘀熨饫毓燠腴狳菀蜮蝓"};
const unsigned char PY_mb_yu    []={0xe4,0xb8,0x8e,0xe4,0xba,0x8e,0xe6,0xac,0xb2,0xe9,0xb1,0xbc,0xe9,0x9b,0xa8,0xe4,0xbd,0x99,0xe9,0x81,0x87,0xe8,0xaf,0xad,0xe6,0x84,0x88,0xe7,0x8b,0xb1,0xe7,0x8e,0x89,0xe6,0xb8,0x94,0xe4,0xba,0x88,0xe8,0xaa,0x89,0xe8,0x82,0xb2,0xe6,0x84,0x9a,0xe7,0xbe,0xbd,0xe8,0x99,0x9e,0xe5,0xa8,0xb1,0xe6,0xb7,0xa4,0xe8,0x88,0x86,0xe5,0xb1,0xbf,0xe7,0xa6,0xb9,0xe5,0xae,0x87,0xe8,0xbf,0x82,0xe4,0xbf,0x9e,0xe9,0x80,0xbe,0xe5,0x9f,0x9f,0xe8,0x8a,0x8b,0xe9,0x83,0x81,0xe8,0xb0,0xb7,0xe5,0x90,0x81,0xe7,0x9b,0x82,0xe5,0x96,0xbb,0xe5,0xb3,0xaa,0xe5,0xbe,0xa1,0xe6,0x84,0x89,0xe7,0xb2,0xa5,0xe6,0xb8,0x9d,0xe5,0xb0,0x89,0xe6,0xa6,0x86,0xe9,0x9a,0x85,0xe6,0xb5,0xb4,0xe5,0xaf,0x93,0xe8,0xa3,0x95,0xe9,0xa2,0x84,0xe8,0xb1,0xab,0xe9,0xa9,0xad,0xe8,0x94,0x9a,0xe5,0xa6,0xaa,0xe5,0xb5,0x9b,0xe9,0x9b,0xa9,0xe9,0xa6,0x80,0xe9,0x98,0x88,0xe7,0xaa,0xac,0xe9,0xb9,0x86,0xe5,0xa6,0xa4,0xe6,0x8f,0x84,0xe7,0xaa,0xb3,0xe8,0xa7,0x8e,0xe8,0x87,0xbe,0xe8,0x88,0x81,0xe9,0xbe,0x89,0xe8,0x93,0xa3,0xe7,0x85,0x9c,0xe9,0x92,0xb0,0xe8,0xb0,0x80,0xe7,0xba,0xa1,0xe6,0x96,0xbc,0xe7,0xab,0xbd,0xe7,0x91,0x9c,0xe7,0xa6,0xba,0xe8,0x81,0xbf,0xe6,0xac,0xa4,0xe4,0xbf,0xa3,0xe4,0xbc,0x9b,0xe5,0x9c,0x84,0xe9,0xb9,0xac,0xe5,0xba,0xbe,0xe6,0x98,0xb1,0xe8,0x90,0xb8,0xe7,0x98,0x90,0xe8,0xb0,0x95,0xe9,0xac,0xbb,0xe5,0x9c,0x89,0xe7,0x98,0x80,0xe7,0x86,0xa8,0xe9,0xa5,0xab,0xe6,0xaf,0x93,0xe7,0x87,0xa0,0xe8,0x85,0xb4,0xe7,0x8b,0xb3,0xe8,0x8f,0x80,0xe8,0x9c,0xae,0xe8,0x9d,0x93,0x00};

//const unsigned char PY_mb_yuan  []={"远员元院圆原愿园援猿怨冤源缘袁渊苑垣鸳辕圜鼋橼媛爰眢鸢掾芫沅瑗螈箢塬垸"};
const unsigned char PY_mb_yuan  []={0xe8,0xbf,0x9c,0xe5,0x91,0x98,0xe5,0x85,0x83,0xe9,0x99,0xa2,0xe5,0x9c,0x86,0xe5,0x8e,0x9f,0xe6,0x84,0xbf,0xe5,0x9b,0xad,0xe6,0x8f,0xb4,0xe7,0x8c,0xbf,0xe6,0x80,0xa8,0xe5,0x86,0xa4,0xe6,0xba,0x90,0xe7,0xbc,0x98,0xe8,0xa2,0x81,0xe6,0xb8,0x8a,0xe8,0x8b,0x91,0xe5,0x9e,0xa3,0xe9,0xb8,0xb3,0xe8,0xbe,0x95,0xe5,0x9c,0x9c,0xe9,0xbc,0x8b,0xe6,0xa9,0xbc,0xe5,0xaa,0x9b,0xe7,0x88,0xb0,0xe7,0x9c,0xa2,0xe9,0xb8,0xa2,0xe6,0x8e,0xbe,0xe8,0x8a,0xab,0xe6,0xb2,0x85,0xe7,0x91,0x97,0xe8,0x9e,0x88,0xe7,0xae,0xa2,0xe5,0xa1,0xac,0xe5,0x9e,0xb8,0x00};

//const unsigned char PY_mb_yue   []={"月越约跃阅乐岳悦曰说粤钥瀹钺刖龠栎樾"};
const unsigned char PY_mb_yue   []={0xe6,0x9c,0x88,0xe8,0xb6,0x8a,0xe7,0xba,0xa6,0xe8,0xb7,0x83,0xe9,0x98,0x85,0xe4,0xb9,0x90,0xe5,0xb2,0xb3,0xe6,0x82,0xa6,0xe6,0x9b,0xb0,0xe8,0xaf,0xb4,0xe7,0xb2,0xa4,0xe9,0x92,0xa5,0xe7,0x80,0xb9,0xe9,0x92,0xba,0xe5,0x88,0x96,0xe9,0xbe,0xa0,0xe6,0xa0,0x8e,0xe6,0xa8,0xbe,0x00};

//const unsigned char PY_mb_yun   []={"云运晕允匀韵陨孕耘蕴酝郧员熨氲恽愠郓芸筠韫昀狁殒纭"};
const unsigned char PY_mb_yun   []={0xe4,0xba,0x91,0xe8,0xbf,0x90,0xe6,0x99,0x95,0xe5,0x85,0x81,0xe5,0x8c,0x80,0xe9,0x9f,0xb5,0xe9,0x99,0xa8,0xe5,0xad,0x95,0xe8,0x80,0x98,0xe8,0x95,0xb4,0xe9,0x85,0x9d,0xe9,0x83,0xa7,0xe5,0x91,0x98,0xe7,0x86,0xa8,0xe6,0xb0,0xb2,0xe6,0x81,0xbd,0xe6,0x84,0xa0,0xe9,0x83,0x93,0xe8,0x8a,0xb8,0xe7,0xad,0xa0,0xe9,0x9f,0xab,0xe6,0x98,0x80,0xe7,0x8b,0x81,0xe6,0xae,0x92,0xe7,0xba,0xad,0x00};

//const unsigned char PY_mb_za    []={"杂砸咋匝扎咱咂拶"};
const unsigned char PY_mb_za    []={0xe6,0x9d,0x82,0xe7,0xa0,0xb8,0xe5,0x92,0x8b,0xe5,0x8c,0x9d,0xe6,0x89,0x8e,0xe5,0x92,0xb1,0xe5,0x92,0x82,0xe6,0x8b,0xb6,0x00};

//const unsigned char PY_mb_zai   []={"在再灾载栽宰哉崽甾仔"};
const unsigned char PY_mb_zai   []={0xe5,0x9c,0xa8,0xe5,0x86,0x8d,0xe7,0x81,0xbe,0xe8,0xbd,0xbd,0xe6,0xa0,0xbd,0xe5,0xae,0xb0,0xe5,0x93,0x89,0xe5,0xb4,0xbd,0xe7,0x94,0xbe,0xe4,0xbb,0x94,0x00};

//const unsigned char PY_mb_zan   []={"咱暂攒赞簪趱糌瓒拶昝錾"};
const unsigned char PY_mb_zan   []={0xe5,0x92,0xb1,0xe6,0x9a,0x82,0xe6,0x94,0x92,0xe8,0xb5,0x9e,0xe7,0xb0,0xaa,0xe8,0xb6,0xb1,0xe7,0xb3,0x8c,0xe7,0x93,0x92,0xe6,0x8b,0xb6,0xe6,0x98,0x9d,0xe9,0x8c,0xbe,0x00};

//const unsigned char PY_mb_zang  []={"脏葬赃藏臧驵奘"};
const unsigned char PY_mb_zang  []={0xe8,0x84,0x8f,0xe8,0x91,0xac,0xe8,0xb5,0x83,0xe8,0x97,0x8f,0xe8,0x87,0xa7,0xe9,0xa9,0xb5,0xe5,0xa5,0x98,0x00};

//const unsigned char PY_mb_zao   []={"早造遭糟灶燥枣凿躁藻皂噪澡蚤唣"};
const unsigned char PY_mb_zao   []={0xe6,0x97,0xa9,0xe9,0x80,0xa0,0xe9,0x81,0xad,0xe7,0xb3,0x9f,0xe7,0x81,0xb6,0xe7,0x87,0xa5,0xe6,0x9e,0xa3,0xe5,0x87,0xbf,0xe8,0xba,0x81,0xe8,0x97,0xbb,0xe7,0x9a,0x82,0xe5,0x99,0xaa,0xe6,0xbe,0xa1,0xe8,0x9a,0xa4,0xe5,0x94,0xa3,0x00};

//const unsigned char PY_mb_ze    []={"则责择泽咋侧箦舴帻迮啧仄昃笮赜"};
const unsigned char PY_mb_ze    []={0xe5,0x88,0x99,0xe8,0xb4,0xa3,0xe6,0x8b,0xa9,0xe6,0xb3,0xbd,0xe5,0x92,0x8b,0xe4,0xbe,0xa7,0xe7,0xae,0xa6,0xe8,0x88,0xb4,0xe5,0xb8,0xbb,0xe8,0xbf,0xae,0xe5,0x95,0xa7,0xe4,0xbb,0x84,0xe6,0x98,0x83,0xe7,0xac,0xae,0xe8,0xb5,0x9c,0x00};

//const unsigned char PY_mb_zei   []={"贼"};
const unsigned char PY_mb_zei   []={0xe8,0xb4,0xbc,0x00};

//const unsigned char PY_mb_zen   []={"怎谮"};
const unsigned char PY_mb_zen   []={0xe6,0x80,0x8e,0xe8,0xb0,0xae,0x00};

//const unsigned char PY_mb_zeng  []={"增赠憎曾综缯罾甑锃"};
const unsigned char PY_mb_zeng  []={0xe5,0xa2,0x9e,0xe8,0xb5,0xa0,0xe6,0x86,0x8e,0xe6,0x9b,0xbe,0xe7,0xbb,0xbc,0xe7,0xbc,0xaf,0xe7,0xbd,0xbe,0xe7,0x94,0x91,0xe9,0x94,0x83,0x00};

//const unsigned char PY_mb_zha   []={"扎炸渣闸眨榨乍轧诈喳札铡揸吒咤哳猹砟痄蚱齄查蜡栅咋喋楂柞"};
const unsigned char PY_mb_zha   []={0xe6,0x89,0x8e,0xe7,0x82,0xb8,0xe6,0xb8,0xa3,0xe9,0x97,0xb8,0xe7,0x9c,0xa8,0xe6,0xa6,0xa8,0xe4,0xb9,0x8d,0xe8,0xbd,0xa7,0xe8,0xaf,0x88,0xe5,0x96,0xb3,0xe6,0x9c,0xad,0xe9,0x93,0xa1,0xe6,0x8f,0xb8,0xe5,0x90,0x92,0xe5,0x92,0xa4,0xe5,0x93,0xb3,0xe7,0x8c,0xb9,0xe7,0xa0,0x9f,0xe7,0x97,0x84,0xe8,0x9a,0xb1,0xe9,0xbd,0x84,0xe6,0x9f,0xa5,0xe8,0x9c,0xa1,0xe6,0xa0,0x85,0xe5,0x92,0x8b,0xe5,0x96,0x8b,0xe6,0xa5,0x82,0xe6,0x9f,0x9e,0x00};

//const unsigned char PY_mb_zhai  []={"摘窄债斋寨择翟宅侧祭砦瘵"};
const unsigned char PY_mb_zhai  []={0xe6,0x91,0x98,0xe7,0xaa,0x84,0xe5,0x80,0xba,0xe6,0x96,0x8b,0xe5,0xaf,0xa8,0xe6,0x8b,0xa9,0xe7,0xbf,0x9f,0xe5,0xae,0x85,0xe4,0xbe,0xa7,0xe7,0xa5,0xad,0xe7,0xa0,0xa6,0xe7,0x98,0xb5,0x00};

//const unsigned char PY_mb_zhan  []={"站占战盏沾粘毡展栈詹颤蘸湛绽斩辗崭瞻谵搌旃"};
const unsigned char PY_mb_zhan  []={0xe7,0xab,0x99,0xe5,0x8d,0xa0,0xe6,0x88,0x98,0xe7,0x9b,0x8f,0xe6,0xb2,0xbe,0xe7,0xb2,0x98,0xe6,0xaf,0xa1,0xe5,0xb1,0x95,0xe6,0xa0,0x88,0xe8,0xa9,0xb9,0xe9,0xa2,0xa4,0xe8,0x98,0xb8,0xe6,0xb9,0x9b,0xe7,0xbb,0xbd,0xe6,0x96,0xa9,0xe8,0xbe,0x97,0xe5,0xb4,0xad,0xe7,0x9e,0xbb,0xe8,0xb0,0xb5,0xe6,0x90,0x8c,0xe6,0x97,0x83,0x00};

//const unsigned char PY_mb_zhang []={"张章长帐仗丈掌涨账樟杖彰漳胀瘴障仉嫜幛鄣璋嶂獐蟑"};
const unsigned char PY_mb_zhang []={0xe5,0xbc,0xa0,0xe7,0xab,0xa0,0xe9,0x95,0xbf,0xe5,0xb8,0x90,0xe4,0xbb,0x97,0xe4,0xb8,0x88,0xe6,0x8e,0x8c,0xe6,0xb6,0xa8,0xe8,0xb4,0xa6,0xe6,0xa8,0x9f,0xe6,0x9d,0x96,0xe5,0xbd,0xb0,0xe6,0xbc,0xb3,0xe8,0x83,0x80,0xe7,0x98,0xb4,0xe9,0x9a,0x9c,0xe4,0xbb,0x89,0xe5,0xab,0x9c,0xe5,0xb9,0x9b,0xe9,0x84,0xa3,0xe7,0x92,0x8b,0xe5,0xb6,0x82,0xe7,0x8d,0x90,0xe8,0x9f,0x91,0x00};

//const unsigned char PY_mb_zhao  []={"找着照招罩爪兆朝昭沼肇嘲召赵棹钊笊诏啁"};
const unsigned char PY_mb_zhao  []={0xe6,0x89,0xbe,0xe7,0x9d,0x80,0xe7,0x85,0xa7,0xe6,0x8b,0x9b,0xe7,0xbd,0xa9,0xe7,0x88,0xaa,0xe5,0x85,0x86,0xe6,0x9c,0x9d,0xe6,0x98,0xad,0xe6,0xb2,0xbc,0xe8,0x82,0x87,0xe5,0x98,0xb2,0xe5,0x8f,0xac,0xe8,0xb5,0xb5,0xe6,0xa3,0xb9,0xe9,0x92,0x8a,0xe7,0xac,0x8a,0xe8,0xaf,0x8f,0xe5,0x95,0x81,0x00};

//const unsigned char PY_mb_zhe   []={"着这者折遮蛰哲蔗锗辙浙柘辄赭摺鹧磔褶蜇谪"};
const unsigned char PY_mb_zhe   []={0xe7,0x9d,0x80,0xe8,0xbf,0x99,0xe8,0x80,0x85,0xe6,0x8a,0x98,0xe9,0x81,0xae,0xe8,0x9b,0xb0,0xe5,0x93,0xb2,0xe8,0x94,0x97,0xe9,0x94,0x97,0xe8,0xbe,0x99,0xe6,0xb5,0x99,0xe6,0x9f,0x98,0xe8,0xbe,0x84,0xe8,0xb5,0xad,0xe6,0x91,0xba,0xe9,0xb9,0xa7,0xe7,0xa3,0x94,0xe8,0xa4,0xb6,0xe8,0x9c,0x87,0xe8,0xb0,0xaa,0x00};

//const unsigned char PY_mb_zhen  []={"真阵镇针震枕振斟珍疹诊甄砧臻贞侦缜蓁祯箴轸榛稹赈朕鸩胗浈桢畛圳椹"};
const unsigned char PY_mb_zhen  []={0xe7,0x9c,0x9f,0xe9,0x98,0xb5,0xe9,0x95,0x87,0xe9,0x92,0x88,0xe9,0x9c,0x87,0xe6,0x9e,0x95,0xe6,0x8c,0xaf,0xe6,0x96,0x9f,0xe7,0x8f,0x8d,0xe7,0x96,0xb9,0xe8,0xaf,0x8a,0xe7,0x94,0x84,0xe7,0xa0,0xa7,0xe8,0x87,0xbb,0xe8,0xb4,0x9e,0xe4,0xbe,0xa6,0xe7,0xbc,0x9c,0xe8,0x93,0x81,0xe7,0xa5,0xaf,0xe7,0xae,0xb4,0xe8,0xbd,0xb8,0xe6,0xa6,0x9b,0xe7,0xa8,0xb9,0xe8,0xb5,0x88,0xe6,0x9c,0x95,0xe9,0xb8,0xa9,0xe8,0x83,0x97,0xe6,0xb5,0x88,0xe6,0xa1,0xa2,0xe7,0x95,0x9b,0xe5,0x9c,0xb3,0xe6,0xa4,0xb9,0x00};

//const unsigned char PY_mb_zheng []={"正整睁争挣征怔证症郑拯蒸狰政帧峥钲铮筝诤徵丁鲭"};
const unsigned char PY_mb_zheng []={0xe6,0xad,0xa3,0xe6,0x95,0xb4,0xe7,0x9d,0x81,0xe4,0xba,0x89,0xe6,0x8c,0xa3,0xe5,0xbe,0x81,0xe6,0x80,0x94,0xe8,0xaf,0x81,0xe7,0x97,0x87,0xe9,0x83,0x91,0xe6,0x8b,0xaf,0xe8,0x92,0xb8,0xe7,0x8b,0xb0,0xe6,0x94,0xbf,0xe5,0xb8,0xa7,0xe5,0xb3,0xa5,0xe9,0x92,0xb2,0xe9,0x93,0xae,0xe7,0xad,0x9d,0xe8,0xaf,0xa4,0xe5,0xbe,0xb5,0xe4,0xb8,0x81,0xe9,0xb2,0xad,0x00};

//const unsigned char PY_mb_zhi   []={"只之直知制指纸支芝枝稚吱蜘质肢脂汁炙织职痔植抵殖执值侄址智滞止趾治旨窒志挚掷至致置帜识峙氏秩帙摭黹桎枳轵忮祉蛭膣觯郅栀彘芷祗咫鸷絷踬胝骘轾痣陟踯雉埴贽卮酯豸跖栉伎"};
const unsigned char PY_mb_zhi   []={0xe5,0x8f,0xaa,0xe4,0xb9,0x8b,0xe7,0x9b,0xb4,0xe7,0x9f,0xa5,0xe5,0x88,0xb6,0xe6,0x8c,0x87,0xe7,0xba,0xb8,0xe6,0x94,0xaf,0xe8,0x8a,0x9d,0xe6,0x9e,0x9d,0xe7,0xa8,0x9a,0xe5,0x90,0xb1,0xe8,0x9c,0x98,0xe8,0xb4,0xa8,0xe8,0x82,0xa2,0xe8,0x84,0x82,0xe6,0xb1,0x81,0xe7,0x82,0x99,0xe7,0xbb,0x87,0xe8,0x81,0x8c,0xe7,0x97,0x94,0xe6,0xa4,0x8d,0xe6,0x8a,0xb5,0xe6,0xae,0x96,0xe6,0x89,0xa7,0xe5,0x80,0xbc,0xe4,0xbe,0x84,0xe5,0x9d,0x80,0xe6,0x99,0xba,0xe6,0xbb,0x9e,0xe6,0xad,0xa2,0xe8,0xb6,0xbe,0xe6,0xb2,0xbb,0xe6,0x97,0xa8,0xe7,0xaa,0x92,0xe5,0xbf,0x97,0xe6,0x8c,0x9a,0xe6,0x8e,0xb7,0xe8,0x87,0xb3,0xe8,0x87,0xb4,0xe7,0xbd,0xae,0xe5,0xb8,0x9c,0xe8,0xaf,0x86,0xe5,0xb3,0x99,0xe6,0xb0,0x8f,0xe7,0xa7,0xa9,0xe5,0xb8,0x99,0xe6,0x91,0xad,0xe9,0xbb,0xb9,0xe6,0xa1,0x8e,0xe6,0x9e,0xb3,0xe8,0xbd,0xb5,0xe5,0xbf,0xae,0xe7,0xa5,0x89,0xe8,0x9b,0xad,0xe8,0x86,0xa3,0xe8,0xa7,0xaf,0xe9,0x83,0x85,0xe6,0xa0,0x80,0xe5,0xbd,0x98,0xe8,0x8a,0xb7,0xe7,0xa5,0x97,0xe5,0x92,0xab,0xe9,0xb8,0xb7,0xe7,0xb5,0xb7,0xe8,0xb8,0xac,0xe8,0x83,0x9d,0xe9,0xaa,0x98,0xe8,0xbd,0xbe,0xe7,0x97,0xa3,0xe9,0x99,0x9f,0xe8,0xb8,0xaf,0xe9,0x9b,0x89,0xe5,0x9f,0xb4,0xe8,0xb4,0xbd,0xe5,0x8d,0xae,0xe9,0x85,0xaf,0xe8,0xb1,0xb8,0xe8,0xb7,0x96,0xe6,0xa0,0x89,0xe4,0xbc,0x8e,0x00};

//const unsigned char PY_mb_zhong []={"中重种钟肿众终盅忠仲衷踵舯螽锺冢忪"};
const unsigned char PY_mb_zhong []={0xe4,0xb8,0xad,0xe9,0x87,0x8d,0xe7,0xa7,0x8d,0xe9,0x92,0x9f,0xe8,0x82,0xbf,0xe4,0xbc,0x97,0xe7,0xbb,0x88,0xe7,0x9b,0x85,0xe5,0xbf,0xa0,0xe4,0xbb,0xb2,0xe8,0xa1,0xb7,0xe8,0xb8,0xb5,0xe8,0x88,0xaf,0xe8,0x9e,0xbd,0xe9,0x94,0xba,0xe5,0x86,0xa2,0xe5,0xbf,0xaa,0x00};

//const unsigned char PY_mb_zhou  []={"周洲皱粥州轴舟昼骤宙诌肘帚咒繇胄纣荮啁碡绉籀妯酎"};
const unsigned char PY_mb_zhou  []={0xe5,0x91,0xa8,0xe6,0xb4,0xb2,0xe7,0x9a,0xb1,0xe7,0xb2,0xa5,0xe5,0xb7,0x9e,0xe8,0xbd,0xb4,0xe8,0x88,0x9f,0xe6,0x98,0xbc,0xe9,0xaa,0xa4,0xe5,0xae,0x99,0xe8,0xaf,0x8c,0xe8,0x82,0x98,0xe5,0xb8,0x9a,0xe5,0x92,0x92,0xe7,0xb9,0x87,0xe8,0x83,0x84,0xe7,0xba,0xa3,0xe8,0x8d,0xae,0xe5,0x95,0x81,0xe7,0xa2,0xa1,0xe7,0xbb,0x89,0xe7,0xb1,0x80,0xe5,0xa6,0xaf,0xe9,0x85,0x8e,0x00};

//const unsigned char PY_mb_zhu   []={"住主猪竹株煮筑著珠蛛朱诸诛逐烛拄瞩嘱柱助蛀贮铸注祝驻伫潴洙瘃翥茱苎橥舳杼箸炷侏铢疰渚褚躅麈邾槠竺属术"};
const unsigned char PY_mb_zhu   []={0xe4,0xbd,0x8f,0xe4,0xb8,0xbb,0xe7,0x8c,0xaa,0xe7,0xab,0xb9,0xe6,0xa0,0xaa,0xe7,0x85,0xae,0xe7,0xad,0x91,0xe8,0x91,0x97,0xe7,0x8f,0xa0,0xe8,0x9b,0x9b,0xe6,0x9c,0xb1,0xe8,0xaf,0xb8,0xe8,0xaf,0x9b,0xe9,0x80,0x90,0xe7,0x83,0x9b,0xe6,0x8b,0x84,0xe7,0x9e,0xa9,0xe5,0x98,0xb1,0xe6,0x9f,0xb1,0xe5,0x8a,0xa9,0xe8,0x9b,0x80,0xe8,0xb4,0xae,0xe9,0x93,0xb8,0xe6,0xb3,0xa8,0xe7,0xa5,0x9d,0xe9,0xa9,0xbb,0xe4,0xbc,0xab,0xe6,0xbd,0xb4,0xe6,0xb4,0x99,0xe7,0x98,0x83,0xe7,0xbf,0xa5,0xe8,0x8c,0xb1,0xe8,0x8b,0x8e,0xe6,0xa9,0xa5,0xe8,0x88,0xb3,0xe6,0x9d,0xbc,0xe7,0xae,0xb8,0xe7,0x82,0xb7,0xe4,0xbe,0x8f,0xe9,0x93,0xa2,0xe7,0x96,0xb0,0xe6,0xb8,0x9a,0xe8,0xa4,0x9a,0xe8,0xba,0x85,0xe9,0xba,0x88,0xe9,0x82,0xbe,0xe6,0xa7,0xa0,0xe7,0xab,0xba,0xe5,0xb1,0x9e,0xe6,0x9c,0xaf,0x00};

//const unsigned char PY_mb_zhua  []={"抓爪挝"};
const unsigned char PY_mb_zhua  []={0xe6,0x8a,0x93,0xe7,0x88,0xaa,0xe6,0x8c,0x9d,0x00};

//const unsigned char PY_mb_zhuai []={"拽转"};
const unsigned char PY_mb_zhuai []={0xe6,0x8b,0xbd,0xe8,0xbd,0xac,0x00};

//const unsigned char PY_mb_zhuan []={"转专砖赚传撰篆颛馔啭沌"};
const unsigned char PY_mb_zhuan []={0xe8,0xbd,0xac,0xe4,0xb8,0x93,0xe7,0xa0,0x96,0xe8,0xb5,0x9a,0xe4,0xbc,0xa0,0xe6,0x92,0xb0,0xe7,0xaf,0x86,0xe9,0xa2,0x9b,0xe9,0xa6,0x94,0xe5,0x95,0xad,0xe6,0xb2,0x8c,0x00};

//const unsigned char PY_mb_zhuang[]={"装撞庄壮桩状幢妆僮奘戆"};
const unsigned char PY_mb_zhuang[]={0xe8,0xa3,0x85,0xe6,0x92,0x9e,0xe5,0xba,0x84,0xe5,0xa3,0xae,0xe6,0xa1,0xa9,0xe7,0x8a,0xb6,0xe5,0xb9,0xa2,0xe5,0xa6,0x86,0xe5,0x83,0xae,0xe5,0xa5,0x98,0xe6,0x88,0x86,0x00};

//const unsigned char PY_mb_zhui  []={"追坠缀锥赘椎骓惴缒隹"};
const unsigned char PY_mb_zhui  []={0xe8,0xbf,0xbd,0xe5,0x9d,0xa0,0xe7,0xbc,0x80,0xe9,0x94,0xa5,0xe8,0xb5,0x98,0xe6,0xa4,0x8e,0xe9,0xaa,0x93,0xe6,0x83,0xb4,0xe7,0xbc,0x92,0xe9,0x9a,0xb9,0x00};

//const unsigned char PY_mb_zhun  []={"准谆屯肫窀"};
const unsigned char PY_mb_zhun  []={0xe5,0x87,0x86,0xe8,0xb0,0x86,0xe5,0xb1,0xaf,0xe8,0x82,0xab,0xe7,0xaa,0x80,0x00};

//const unsigned char PY_mb_zhuo  []={"捉桌着啄拙灼浊卓琢缴茁酌擢焯濯诼浞涿倬镯禚斫"};
const unsigned char PY_mb_zhuo  []={0xe6,0x8d,0x89,0xe6,0xa1,0x8c,0xe7,0x9d,0x80,0xe5,0x95,0x84,0xe6,0x8b,0x99,0xe7,0x81,0xbc,0xe6,0xb5,0x8a,0xe5,0x8d,0x93,0xe7,0x90,0xa2,0xe7,0xbc,0xb4,0xe8,0x8c,0x81,0xe9,0x85,0x8c,0xe6,0x93,0xa2,0xe7,0x84,0xaf,0xe6,0xbf,0xaf,0xe8,0xaf,0xbc,0xe6,0xb5,0x9e,0xe6,0xb6,0xbf,0xe5,0x80,0xac,0xe9,0x95,0xaf,0xe7,0xa6,0x9a,0xe6,0x96,0xab,0x00};

//const unsigned char PY_mb_zi    []={"字自子紫籽资姿吱滓仔咨孜渍滋淄谘茈嵫姊孳缁梓辎赀恣眦锱秭耔笫粢趑訾龇鲻髭兹觜"};
const unsigned char PY_mb_zi    []={0xe5,0xad,0x97,0xe8,0x87,0xaa,0xe5,0xad,0x90,0xe7,0xb4,0xab,0xe7,0xb1,0xbd,0xe8,0xb5,0x84,0xe5,0xa7,0xbf,0xe5,0x90,0xb1,0xe6,0xbb,0x93,0xe4,0xbb,0x94,0xe5,0x92,0xa8,0xe5,0xad,0x9c,0xe6,0xb8,0x8d,0xe6,0xbb,0x8b,0xe6,0xb7,0x84,0xe8,0xb0,0x98,0xe8,0x8c,0x88,0xe5,0xb5,0xab,0xe5,0xa7,0x8a,0xe5,0xad,0xb3,0xe7,0xbc,0x81,0xe6,0xa2,0x93,0xe8,0xbe,0x8e,0xe8,0xb5,0x80,0xe6,0x81,0xa3,0xe7,0x9c,0xa6,0xe9,0x94,0xb1,0xe7,0xa7,0xad,0xe8,0x80,0x94,0xe7,0xac,0xab,0xe7,0xb2,0xa2,0xe8,0xb6,0x91,0xe8,0xa8,0xbe,0xe9,0xbe,0x87,0xe9,0xb2,0xbb,0xe9,0xab,0xad,0xe5,0x85,0xb9,0xe8,0xa7,0x9c,0x00};

//const unsigned char PY_mb_zong  []={"总纵宗棕综踪鬃偬粽枞腙"};
const unsigned char PY_mb_zong  []={0xe6,0x80,0xbb,0xe7,0xba,0xb5,0xe5,0xae,0x97,0xe6,0xa3,0x95,0xe7,0xbb,0xbc,0xe8,0xb8,0xaa,0xe9,0xac,0x83,0xe5,0x81,0xac,0xe7,0xb2,0xbd,0xe6,0x9e,0x9e,0xe8,0x85,0x99,0x00};

//const unsigned char PY_mb_zou   []={"走揍奏邹鲰鄹陬驺诹"};
const unsigned char PY_mb_zou   []={0xe8,0xb5,0xb0,0xe6,0x8f,0x8d,0xe5,0xa5,0x8f,0xe9,0x82,0xb9,0xe9,0xb2,0xb0,0xe9,0x84,0xb9,0xe9,0x99,0xac,0xe9,0xa9,0xba,0xe8,0xaf,0xb9,0x00};

//const unsigned char PY_mb_zu    []={"组族足阻租祖诅菹镞卒俎"};
const unsigned char PY_mb_zu    []={0xe7,0xbb,0x84,0xe6,0x97,0x8f,0xe8,0xb6,0xb3,0xe9,0x98,0xbb,0xe7,0xa7,0x9f,0xe7,0xa5,0x96,0xe8,0xaf,0x85,0xe8,0x8f,0xb9,0xe9,0x95,0x9e,0xe5,0x8d,0x92,0xe4,0xbf,0x8e,0x00};

//const unsigned char PY_mb_zuan  []={"钻纂赚攥缵躜"};
const unsigned char PY_mb_zuan  []={0xe9,0x92,0xbb,0xe7,0xba,0x82,0xe8,0xb5,0x9a,0xe6,0x94,0xa5,0xe7,0xbc,0xb5,0xe8,0xba,0x9c,0x00};

//const unsigned char PY_mb_zui   []={"最嘴醉罪堆咀觜蕞"};
const unsigned char PY_mb_zui   []={0xe6,0x9c,0x80,0xe5,0x98,0xb4,0xe9,0x86,0x89,0xe7,0xbd,0xaa,0xe5,0xa0,0x86,0xe5,0x92,0x80,0xe8,0xa7,0x9c,0xe8,0x95,0x9e,0x00};

//const unsigned char PY_mb_zun   []={"尊遵撙樽鳟"};
const unsigned char PY_mb_zun   []={0xe5,0xb0,0x8a,0xe9,0x81,0xb5,0xe6,0x92,0x99,0xe6,0xa8,0xbd,0xe9,0xb3,0x9f,0x00};

//const unsigned char PY_mb_zuo   []={"做作坐左座昨凿佐阼唑怍胙祚撮琢嘬笮酢柞"};
const unsigned char PY_mb_zuo   []={0xe5,0x81,0x9a,0xe4,0xbd,0x9c,0xe5,0x9d,0x90,0xe5,0xb7,0xa6,0xe5,0xba,0xa7,0xe6,0x98,0xa8,0xe5,0x87,0xbf,0xe4,0xbd,0x90,0xe9,0x98,0xbc,0xe5,0x94,0x91,0xe6,0x80,0x8d,0xe8,0x83,0x99,0xe7,0xa5,0x9a,0xe6,0x92,0xae,0xe7,0x90,0xa2,0xe5,0x98,0xac,0xe7,0xac,0xae,0xe9,0x85,0xa2,0xe6,0x9f,0x9e,0x00};

//const unsigned char PY_mb_bd    []={",.?!:;'\"()<>[]{}$%@*+-_=~`|/\\^&*"};
const unsigned char PY_mb_bd    []={0x2c,0x2e,0x3f,0x21,0x3a,0x3b,0x27,0x5c,0x22,0x28,0x29,0x3c,0x3e,0x5b,0x5d,0x00};

//const unsigned char PY_mb_sz    []={"0123456789"}; //数字
const unsigned char PY_mb_sz    []={0x30,0x31,0x32,0x33,0x34,0x35,0x36,0x37,0x38,0x39,0x00};

//const unsigned char PY_mb_abc   []={"abc"};
const unsigned char PY_mb_abc   []={0x61,0x62,0x63,0x00};

//const unsigned char PY_mb_def   []={"def"};
const unsigned char PY_mb_def   []={0x64,0x65,0x66,0x00};

//const unsigned char PY_mb_ghi   []={"ghi"};
const unsigned char PY_mb_ghi   []={0x67,0x68,0x69,0x00};

//const unsigned char PY_mb_jkl   []={"jkl"};
const unsigned char PY_mb_jkl   []={0x6a,0x6b,0x6c,0x00};

//const unsigned char PY_mb_mno   []={"mno"};
const unsigned char PY_mb_mno   []={0x6d,0x6e,0x6f,0x00};

//const unsigned char PY_mb_pqrs  []={"pqrs"};
const unsigned char PY_mb_pqrs  []={0x70,0x71,0x72,0x73,0x00};

//const unsigned char PY_mb_tuv   []={"tuv"};
const unsigned char PY_mb_tuv   []={0x74,0x75,0x76,0x00};

//const unsigned char PY_mb_wxyz  []={"wxyz"};
const unsigned char PY_mb_wxyz  []={0x77,0x78,0x79,0x7a,0x00};

//const unsigned char PY_mb_ABC   []={"ABC"};
const unsigned char PY_mb_ABC   []={0x41,0x42,0x43,0x00};

//const unsigned char PY_mb_DEF   []={"DEF"};
const unsigned char PY_mb_DEF   []={0x44,0x45,0x46,0x00};

//const unsigned char PY_mb_GHI   []={"GHI"};
const unsigned char PY_mb_GHI   []={0x47,0x48,0x49,0x00};

//const unsigned char PY_mb_JKL   []={"JKL"};
const unsigned char PY_mb_JKL   []={0x4a,0x4b,0x4c,0x00};

//const unsigned char PY_mb_MNO   []={"MNO"};
const unsigned char PY_mb_MNO   []={0x4d,0x4e,0x4f,0x00};

//const unsigned char PY_mb_PQRS  []={"PQRS"};
const unsigned char PY_mb_PQRS  []={0x50,0x51,0x52,0x53,0x00};

//const unsigned char PY_mb_TUV   []={"TUV"};
const unsigned char PY_mb_TUV   []={0x54,0x55,0x56,0x00};

//const unsigned char PY_mb_WXYZ  []={"WXYZ"};
const unsigned char PY_mb_WXYZ  []={0x57,0x58,0x59,0x5a,0x00};

#else
/* GBK编码 */

#if 0
const unsigned char PY_mb_space []={""};
const unsigned char PY_mb_a     []={"啊阿呵吖嗄腌锕"}; 
const unsigned char PY_mb_ai    []={"爱矮挨哎碍癌艾唉哀蔼隘埃皑呆嗌嫒瑷暧捱砹嗳锿霭"};
const unsigned char PY_mb_an    []={"按安暗岸俺案鞍氨胺厂广庵揞犴铵桉谙鹌埯黯"};
const unsigned char PY_mb_ang   []={"昂肮盎仰"};
const unsigned char PY_mb_ao    []={"袄凹傲奥熬懊敖翱澳嚣拗媪廒骜嗷坳遨聱螯獒鏊鳌鏖"};
const unsigned char PY_mb_ba    []={"把八吧爸拔罢跋巴芭扒坝霸叭靶笆疤耙捌粑茇岜鲅钯魃"};
const unsigned char PY_mb_bai   []={"百白摆败柏拜佰伯稗捭呗掰"};
const unsigned char PY_mb_ban   []={"半办班般拌搬版斑板伴扳扮瓣颁绊癍坂钣舨阪"};
const unsigned char PY_mb_bang  []={"帮棒绑磅镑邦榜蚌傍梆膀谤浜蒡"};
const unsigned char PY_mb_bao   []={"包抱报饱保暴薄宝爆剥豹刨雹褒堡苞胞鲍炮瀑龅孢煲褓鸨趵葆"};
const unsigned char PY_mb_bei   []={"被北倍杯背悲备碑卑贝辈钡焙狈惫臂褙悖蓓鹎鐾呗"};
const unsigned char PY_mb_ben   []={"本奔苯笨夯锛贲畚坌"};
const unsigned char PY_mb_beng  []={"蹦绷甭崩迸蚌泵甏嘣"};
const unsigned char PY_mb_bi    []={"比笔闭鼻碧必避逼毕臂彼鄙壁蓖币弊辟蔽毙庇敝陛毖痹秘泌秕薜荸芘萆匕裨畀俾嬖狴筚箅篦舭荜襞庳铋跸吡愎贲滗濞璧哔髀弼妣婢"};
const unsigned char PY_mb_bian  []={"边变便遍编辩扁贬鞭卞辨辫忭砭匾汴碥蝙褊鳊笾苄窆弁缏"};
const unsigned char PY_mb_biao  []={"表标彪膘杓婊飑飙鳔瘭飚镳裱骠镖"};
const unsigned char PY_mb_bie   []={"别憋鳖瘪蹩"};
const unsigned char PY_mb_bin   []={"宾濒摈彬斌滨豳膑殡缤髌傧槟鬓镔玢"};
const unsigned char PY_mb_bing  []={"并病兵冰丙饼屏秉柄炳摒槟禀邴"};
const unsigned char PY_mb_bo    []={"拨波播泊博伯驳玻剥薄勃菠钵搏脖帛般柏舶渤铂箔膊魄卜礴跛檗亳鹁踣啵蕃簸钹饽擘"};
const unsigned char PY_mb_bu    []={"不步补布部捕卜簿哺堡埠怖埔瓿逋晡钸钚醭卟"};
const unsigned char PY_mb_ca    []={"擦拆礤嚓"};
const unsigned char PY_mb_cai   []={"猜才材财裁采彩睬踩菜蔡"};
const unsigned char PY_mb_can   []={"蚕残掺参惨惭餐灿骖璨孱黪粲"};
const unsigned char PY_mb_cang  []={"藏仓沧舱苍伧"};
const unsigned char PY_mb_cao   []={"草操曹槽糙嘈艚螬漕"};
const unsigned char PY_mb_ce    []={"册侧策测厕恻"};
const unsigned char PY_mb_cen   []={"参岑涔"};
const unsigned char PY_mb_ceng  []={"曾层蹭噌"};
const unsigned char PY_mb_cha   []={"查插叉茶差岔搽察茬碴刹诧楂槎镲衩汊馇檫姹杈锸嚓"};
const unsigned char PY_mb_chai  []={"菜柴拆差豺钗瘥虿侪"};
const unsigned char PY_mb_chan  []={"产缠掺搀阐颤铲谗蝉单馋觇婵蒇谄冁廛孱蟾羼镡忏潺禅骣躔澶"};
const unsigned char PY_mb_chang []={"长唱常场厂尝肠畅昌敞倡偿猖裳鲳氅菖惝嫦徜鬯阊怅伥昶苌娼"};
const unsigned char PY_mb_chao  []={"朝抄超吵潮巢炒嘲剿绰钞怊焯耖晁"};
const unsigned char PY_mb_che   []={"车撤扯掣彻尺澈坼砗"};
const unsigned char PY_mb_chen  []={"趁称辰臣尘晨沉陈衬橙忱郴榇抻谌碜谶宸龀嗔伧琛"};
const unsigned char PY_mb_cheng []={"成乘盛撑称城程呈诚惩逞骋澄橙承塍柽埕铖噌铛酲晟裎枨蛏丞瞠"};
const unsigned char PY_mb_chi   []={"吃尺迟池翅痴赤齿耻持斥侈弛驰炽匙踟坻茌墀饬媸豉褫敕哧瘛蚩啻鸱眵螭篪魑叱彳笞嗤"};
const unsigned char PY_mb_chong []={"冲重虫充宠崇涌种艟忡舂铳憧茺"};
const unsigned char PY_mb_chou  []={"抽愁臭仇丑稠绸酬筹踌畴瞅惆俦帱瘳雠"};
const unsigned char PY_mb_chu   []={"出处初锄除触橱楚础储畜滁矗搐躇厨雏楮杵刍怵绌亍憷蹰黜蜍樗"};
const unsigned char PY_mb_chuai []={"揣膪啜嘬搋踹"};
const unsigned char PY_mb_chuan []={"穿船传串川喘椽氚遄钏舡舛巛"};
const unsigned char PY_mb_chuang[]={"窗床闯创疮幢怆"};
const unsigned char PY_mb_chui  []={"吹垂炊锤捶椎槌棰陲"};
const unsigned char PY_mb_chun  []={"春唇纯蠢醇淳椿蝽莼鹑"};
const unsigned char PY_mb_chuo  []={"戳绰踔啜龊辍"};
const unsigned char PY_mb_ci    []={"次此词瓷慈雌磁辞刺茨伺疵赐差兹呲鹚祠糍"};
const unsigned char PY_mb_cong  []={"从丛葱匆聪囱琮枞淙璁骢苁"};
const unsigned char PY_mb_cou   []={"凑楱辏腠"};
const unsigned char PY_mb_cu    []={"粗醋簇促卒徂猝蔟蹙酢殂蹴"};
const unsigned char PY_mb_cuan  []={"窜蹿篡攒撺汆爨镩"};
const unsigned char PY_mb_cui   []={"催脆摧翠崔淬衰瘁粹璀啐悴萃毳榱"};
const unsigned char PY_mb_cun   []={"村寸存蹲忖皴"};
const unsigned char PY_mb_cuo   []={"错撮搓挫措磋嵯厝鹾脞痤蹉瘥锉矬"};
const unsigned char PY_mb_da    []={"大答达打搭瘩塔笪耷哒褡疸怛靼妲沓嗒鞑"};
const unsigned char PY_mb_dai   []={"带代呆戴待袋逮歹贷怠傣大殆呔玳迨岱甙黛骀绐埭"};
const unsigned char PY_mb_dan   []={"但单蛋担弹掸胆淡丹耽旦氮诞郸惮石疸澹瘅萏殚眈聃箪赕儋啖"};
const unsigned char PY_mb_dang  []={"当党挡档荡谠铛宕菪凼裆砀"};
const unsigned char PY_mb_dao   []={"到道倒刀岛盗稻捣悼导蹈祷帱纛忉焘氘叨"};
const unsigned char PY_mb_de    []={"的地得德底锝"};
const unsigned char PY_mb_deng  []={"等灯邓登澄瞪凳蹬磴镫噔嶝戥簦"};
const unsigned char PY_mb_di    []={"地第底低敌抵滴帝递嫡弟缔堤的涤提笛迪狄翟蒂觌邸谛诋嘀柢骶羝氐棣睇娣荻碲镝坻籴砥"};
const unsigned char PY_mb_dia	[]={"嗲"};
const unsigned char PY_mb_dian  []={"点电店殿淀掂颠垫碘惦奠典佃靛滇甸踮钿坫阽癫簟玷巅癜"};
const unsigned char PY_mb_diao  []={"掉钓叼吊雕调刁碉凋鸟铞铫鲷貂"};
const unsigned char PY_mb_die   []={"爹跌叠碟蝶迭谍牒堞瓞揲蹀耋鲽垤喋"};
const unsigned char PY_mb_ding  []={"顶定盯订叮丁钉鼎锭町玎铤腚碇疔仃耵酊啶"};
const unsigned char PY_mb_diu   []={"丢铥"};
const unsigned char PY_mb_dong  []={"动东懂洞冻冬董栋侗恫峒鸫垌胨胴硐氡岽咚"};
const unsigned char PY_mb_dou   []={"都斗豆逗陡抖痘兜读蚪窦篼蔸"};
const unsigned char PY_mb_du    []={"读度毒渡堵独肚镀赌睹杜督都犊妒顿蠹笃嘟渎椟牍黩髑芏"};
const unsigned char PY_mb_duan  []={"段短断端锻缎椴煅簖"};
const unsigned char PY_mb_dui   []={"对队堆兑敦镦碓怼憝"};
const unsigned char PY_mb_dun   []={"吨顿蹲墩敦钝盾囤遁不趸沌盹镦礅炖砘"};
const unsigned char PY_mb_duo   []={"多朵夺舵剁垛跺惰堕掇哆驮度躲踱沲咄铎裰哚缍"};
const unsigned char PY_mb_e     []={"饿哦额鹅蛾扼俄讹阿遏峨娥恶厄鄂锇谔垩锷阏萼苊轭婀莪鳄颚腭愕呃噩鹗屙"};
const unsigned char PY_mb_en    []={"恩摁嗯"};
const unsigned char PY_mb_er    []={"而二耳儿饵尔贰洱珥鲕鸸佴迩铒"};
const unsigned char PY_mb_fa    []={"发法罚伐乏筏阀珐垡砝"};
const unsigned char PY_mb_fan   []={"反饭翻番犯凡帆返泛繁烦贩范樊藩矾钒燔蘩畈蕃蹯梵幡"};
const unsigned char PY_mb_fang  []={"放房防纺芳方访仿坊妨肪钫彷邡枋舫鲂"};
const unsigned char PY_mb_fei   []={"非飞肥费肺废匪吠沸菲诽啡篚蜚腓扉妃斐狒芾悱镄霏翡榧淝鲱绯痱"};
const unsigned char PY_mb_fen   []={"分份芬粉坟奋愤纷忿粪酚焚吩氛汾棼瀵鲼玢偾鼢"};
const unsigned char PY_mb_feng  []={"风封逢缝蜂丰枫疯冯奉讽凤峰锋烽砜俸酆葑沣唪"};
const unsigned char PY_mb_fo    []={"佛"};
const unsigned char PY_mb_fou   []={"否缶"};
const unsigned char PY_mb_fu    []={"副幅扶浮富福负伏付复服附俯斧赴缚拂夫父符孵敷赋辅府腐腹妇抚覆辐肤氟佛俘傅讣弗涪袱市甫釜脯腑阜咐黼砩苻趺跗蚨芾鲋幞茯滏蜉拊菔蝠鳆蝮绂绋赙罘稃匐麸凫桴莩孚馥驸怫祓呋郛芙艴"};
const unsigned char PY_mb_ga    []={"噶胳夹嘎咖轧钆伽旮尬尕尜呷"};
const unsigned char PY_mb_gai   []={"该改盖概钙芥溉戤垓丐陔赅"};
const unsigned char PY_mb_gan   []={"赶干感敢竿甘肝柑杆赣秆旰酐矸疳泔苷擀绀橄澉淦尴坩"};
const unsigned char PY_mb_gang  []={"刚钢纲港缸岗杠冈肛扛筻罡戆"};
const unsigned char PY_mb_gao   []={"高搞告稿膏篙羔糕镐皋郜诰杲缟睾槔锆槁藁"};
const unsigned char PY_mb_ge    []={"个各歌割哥搁格阁隔革咯胳葛蛤戈鸽疙盖屹合铬硌骼颌袼塥虼圪镉仡舸鬲嗝膈搿纥哿"};
const unsigned char PY_mb_gei   []={"给"};
const unsigned char PY_mb_gen   []={"跟根哏茛亘艮"};
const unsigned char PY_mb_geng  []={"更耕颈梗耿庚羹埂赓鲠哽绠"};
const unsigned char PY_mb_gong  []={"工公功共弓攻宫供恭拱贡躬巩汞龚红肱觥珙蚣"};
const unsigned char PY_mb_gou   []={"够沟狗钩勾购构苟垢句岣彀枸鞲觏缑笱诟遘媾篝佝"};
const unsigned char PY_mb_gu    []={"古股鼓谷故孤箍姑顾固雇估咕骨辜沽蛊贾菇梏鸪汩轱崮菰鹄鹘钴臌酤呱鲴诂牯瞽毂锢牿痼觚蛄罟嘏"};
const unsigned char PY_mb_gua   []={"挂刮瓜寡剐褂卦呱胍鸹栝诖"};
const unsigned char PY_mb_guai  []={"怪拐乖掴"};
const unsigned char PY_mb_guan  []={"关管官观馆惯罐灌冠贯棺纶盥矜莞掼涫鳏鹳倌"};
const unsigned char PY_mb_guang []={"光广逛桄犷咣胱"};
const unsigned char PY_mb_gui   []={"归贵鬼跪轨规硅桂柜龟诡闺瑰圭刽傀癸炔庋宄桧刿鳜鲑皈匦妫晷簋炅"};
const unsigned char PY_mb_gun   []={"滚棍辊鲧衮磙绲"};
const unsigned char PY_mb_guo   []={"过国果裹锅郭涡埚椁聒馘猓崞掴帼呙虢蜾蝈"};
const unsigned char PY_mb_ha    []={"哈蛤虾铪"};
const unsigned char PY_mb_hai   []={"还海害咳氦孩骇骸亥嗨醢胲"};
const unsigned char PY_mb_han   []={"喊含汗寒汉旱酣韩焊涵函憨翰罕撼捍憾悍邯邗菡撖瀚阚顸蚶焓颔晗鼾"};
const unsigned char PY_mb_hang  []={"行巷航夯杭吭颃沆绗珩"};
const unsigned char PY_mb_hao   []={"好号浩嚎壕郝毫豪耗貉镐昊颢灏嚆蚝嗥皓蒿濠薅"};
const unsigned char PY_mb_he    []={"和喝合河禾核何呵荷贺赫褐盒鹤菏貉阂涸吓嗬劾盍翮阖颌壑诃纥曷"};
const unsigned char PY_mb_hei   []={"黑嘿"};
const unsigned char PY_mb_hen   []={"很狠恨痕"};
const unsigned char PY_mb_heng  []={"横恒哼衡亨行桁珩蘅"};
const unsigned char PY_mb_hong  []={"红轰哄虹洪宏烘鸿弘讧訇蕻闳薨黉荭泓"};
const unsigned char PY_mb_hou   []={"后厚吼喉侯候猴鲎篌堠後逅糇骺瘊"};
const unsigned char PY_mb_hu    []={"湖户呼虎壶互胡护糊弧忽狐蝴葫沪乎戏核和瑚唬鹕冱怙鹱笏戽扈鹘浒祜醐琥囫烀轷瓠煳斛鹄猢惚岵滹觳唿槲"};
const unsigned char PY_mb_hua   []={"话花化画华划滑哗猾豁铧桦骅砉"};
const unsigned char PY_mb_huai  []={"坏怀淮槐徊划踝"};
const unsigned char PY_mb_huan  []={"换还唤环患缓欢幻宦涣焕豢桓痪漶獾擐逭鲩郇鬟寰奂锾圜洹萑缳浣"};
const unsigned char PY_mb_huang []={"黄慌晃荒簧凰皇谎惶蝗磺恍煌幌隍肓潢篁徨鳇"};
const unsigned char PY_mb_hui   []={"回会灰绘挥汇辉毁悔惠晦徽恢秽慧贿蛔讳徊卉烩诲彗浍珲蕙喙恚哕晖隳麾诙蟪茴洄咴虺荟缋"};
const unsigned char PY_mb_hun   []={"混昏荤浑婚魂阍珲馄溷诨"};
const unsigned char PY_mb_huo   []={"或活火伙货和获祸豁霍惑嚯镬耠劐藿攉锪蠖钬夥"};
const unsigned char PY_mb_ji    []={"几及急既即机鸡积记级极计挤己季寄纪系基激吉脊际击圾畸箕肌饥迹讥姬绩棘辑籍缉集疾汲嫉蓟技冀伎祭剂悸济寂期其奇忌齐妓继给革稽墼洎鲚屐齑戟鲫嵇矶稷戢虮诘笈暨笄剞叽蒺跻嵴掎跽霁唧畿荠瘠玑羁丌偈芨佶赍楫髻咭蕺觊麂"};
const unsigned char PY_mb_jia   []={"家加假价架甲佳夹嘉驾嫁枷荚颊钾稼茄贾铗葭迦戛浃镓痂恝岬跏嘏伽胛笳珈瘕郏袈蛱"};
const unsigned char PY_mb_jian  []={"见件减尖间键贱肩兼建检箭煎简剪歼监坚奸健艰荐剑渐溅涧鉴浅践捡柬笺俭碱硷拣舰槛缄茧饯翦鞯戋谏牮枧腱趼缣搛戬毽菅鲣笕谫楗囝蹇裥踺睑謇鹣蒹僭锏湔"};
const unsigned char PY_mb_jiang []={"将讲江奖降浆僵姜酱蒋疆匠强桨虹豇礓缰犟耩绛茳糨洚"};
const unsigned char PY_mb_jiao  []={"叫脚交角教较缴觉焦胶娇绞校搅骄狡浇矫郊嚼蕉轿窖椒礁饺铰酵侥剿徼艽僬蛟敫峤跤姣皎茭鹪噍醮佼湫鲛挢"};
const unsigned char PY_mb_jie   []={"接节街借皆截解界结届姐揭戒介阶劫芥竭洁疥藉价楷秸桔杰捷诫睫家偈桀喈拮骱羯蚧嗟颉鲒婕碣讦孑疖诘"};
const unsigned char PY_mb_jin   []={"进近今仅紧金斤尽劲禁浸锦晋筋津谨巾襟烬靳廑瑾馑槿衿堇荩矜噤缙卺妗赆觐"};
const unsigned char PY_mb_jing  []={"竟静井惊经镜京净敬精景警竞境径荆晶鲸粳颈兢茎睛劲痉靖肼獍阱腈弪刭憬婧胫菁儆旌迳靓泾"};
const unsigned char PY_mb_jiong []={"窘炯扃迥"};
const unsigned char PY_mb_jiu   []={"就九酒旧久揪救纠舅究韭厩臼玖灸咎疚赳鹫蹴僦柩桕鬏鸠阄啾"};
const unsigned char PY_mb_ju    []={"句举巨局具距锯剧居聚拘菊矩沮拒惧鞠狙驹且据柜桔俱车咀疽踞炬倨醵裾屦犋苴窭飓锔椐苣琚掬榘龃趄莒雎遽橘踽榉鞫钜讵枸"};
const unsigned char PY_mb_juan  []={"卷圈倦鹃捐娟眷绢鄄锩蠲镌狷桊涓隽"};
const unsigned char PY_mb_jue   []={"决绝觉角爵掘诀撅倔抉攫嚼脚桷噱橛嗟觖劂爝矍镢獗珏崛蕨噘谲蹶孓厥"};
const unsigned char PY_mb_jun   []={"军君均菌俊峻龟竣骏钧浚郡筠麇皲捃"};
const unsigned char PY_mb_ka    []={"卡喀咯咖胩咔佧"};
const unsigned char PY_mb_kai   []={"开揩凯慨楷垲剀锎铠锴忾恺蒈"};
const unsigned char PY_mb_kan   []={"看砍堪刊嵌坎槛勘龛戡侃瞰莰阚"};
const unsigned char PY_mb_kang  []={"抗炕扛糠康慷亢钪闶伉"};
const unsigned char PY_mb_kao   []={"靠考烤拷栲犒尻铐"};
const unsigned char PY_mb_ke    []={"咳可克棵科颗刻课客壳渴苛柯磕坷呵恪岢蝌缂蚵轲窠钶氪颏瞌锞稞珂髁疴嗑溘骒"};
const unsigned char PY_mb_ken   []={"肯啃恳垦裉"};
const unsigned char PY_mb_keng  []={"坑吭铿"};
const unsigned char PY_mb_kong  []={"空孔控恐倥崆箜"};
const unsigned char PY_mb_kou   []={"口扣抠寇蔻芤眍筘叩"};
const unsigned char PY_mb_ku    []={"哭库苦枯裤窟酷刳骷喾堀绔"};
const unsigned char PY_mb_kua   []={"跨垮挎夸胯侉"};
const unsigned char PY_mb_kuai  []={"快块筷会侩哙蒯浍郐狯脍"};
const unsigned char PY_mb_kuan  []={"宽款髋"};
const unsigned char PY_mb_kuang []={"矿筐狂框况旷匡眶诳邝纩夼诓圹贶哐"};
const unsigned char PY_mb_kui   []={"亏愧奎窥溃葵魁馈盔傀岿匮愦揆睽跬聩篑喹逵暌蒉悝喟馗蝰隗夔"};
const unsigned char PY_mb_kun   []={"捆困昆坤鲲锟髡琨醌阃悃"};
const unsigned char PY_mb_kuo   []={"阔扩括廓适蛞栝"};
const unsigned char PY_mb_la    []={"拉啦辣蜡腊喇垃蓝落瘌邋砬剌旯"};
const unsigned char PY_mb_lai   []={"来赖莱崃徕涞濑赉睐铼癞籁"};
const unsigned char PY_mb_lan   []={"蓝兰烂拦篮懒栏揽缆滥阑谰婪澜览榄岚褴镧斓罱漤"};
const unsigned char PY_mb_lang  []={"浪狼廊郎朗榔琅稂螂莨啷锒阆蒗"};
const unsigned char PY_mb_lao   []={"老捞牢劳烙涝落姥酪络佬潦耢铹醪铑唠栳崂痨"};
const unsigned char PY_mb_le    []={"了乐勒肋仂叻泐鳓"};
const unsigned char PY_mb_lei   []={"类累泪雷垒勒擂蕾肋镭儡磊缧诔耒酹羸嫘檑嘞"};
const unsigned char PY_mb_leng  []={"冷棱楞塄愣"};
const unsigned char PY_mb_li    []={"里离力立李例哩理利梨厘礼历丽吏犁黎篱狸漓鲤莉荔栗厉励砾傈俐痢粒沥隶璃俪俚郦坜苈莅蓠鹂笠鳢缡跞蜊锂悝澧粝枥蠡鬲呖砺嫠篥疠疬猁藜溧鲡戾栎唳醴轹詈骊罹逦喱雳黧蛎娌"};
const unsigned char PY_mb_lia	[]={"俩"};
const unsigned char PY_mb_lian  []={"连联练莲恋脸炼链敛怜廉帘镰涟蠊琏殓蔹鲢奁潋臁裢濂裣楝"};
const unsigned char PY_mb_liang []={"两亮辆凉粮梁量良晾谅俩粱墚靓踉椋魉莨"};
const unsigned char PY_mb_liao  []={"了料撩聊撂疗廖燎辽僚寥镣潦钌蓼尥寮缭獠鹩嘹"};
const unsigned char PY_mb_lie   []={"列裂猎劣烈咧埒捩鬣趔躐冽洌"};
const unsigned char PY_mb_lin   []={"林临淋邻磷鳞赁吝拎琳霖凛遴嶙蔺粼麟躏辚廪懔瞵檩膦啉"};
const unsigned char PY_mb_ling  []={"另令领零铃玲灵岭龄凌陵菱伶羚棱翎蛉苓绫瓴酃呤泠棂柃鲮聆囹"};
const unsigned char PY_mb_liu   []={"六流留刘柳溜硫瘤榴琉馏碌陆绺锍鎏镏浏骝旒鹨熘遛"};
const unsigned char PY_mb_long  []={"龙拢笼聋隆垄弄咙窿陇垅胧珑茏泷栊癃砻"};
const unsigned char PY_mb_lou   []={"楼搂漏陋露娄篓偻蝼镂蒌耧髅喽瘘嵝"};
const unsigned char PY_mb_lu    []={"路露录鹿陆炉卢鲁卤芦颅庐碌掳绿虏赂戮潞禄麓六鲈栌渌蓼逯泸轳氇簏橹辂垆胪噜"};
const unsigned char PY_mb_luan  []={"乱卵滦峦孪挛栾銮脔娈鸾"};
const unsigned char PY_mb_lue   []={"略掠锊"};
const unsigned char PY_mb_lun   []={"论轮抡伦沦仑纶囵"};
const unsigned char PY_mb_luo   []={"落罗锣裸骡烙箩螺萝洛骆逻络咯荦漯蠃雒倮硌椤捋脶瘰摞泺珞镙猡"};
const unsigned char PY_mb_lv    []={"绿率铝驴旅屡滤吕律氯缕侣虑履偻膂榈闾捋褛稆"};
const unsigned char PY_mb_ma    []={"吗妈马嘛麻骂抹码玛蚂摩唛蟆犸嬷杩"};
const unsigned char PY_mb_mai   []={"买卖迈埋麦脉劢霾荬"};
const unsigned char PY_mb_man   []={"满慢瞒漫蛮蔓曼馒埋谩幔鳗墁螨镘颟鞔缦熳"};
const unsigned char PY_mb_mang  []={"忙芒盲莽茫氓硭邙蟒漭"};
const unsigned char PY_mb_mao   []={"毛冒帽猫矛卯貌茂贸铆锚茅耄茆瑁蝥髦懋昴牦瞀峁袤蟊旄泖"};
const unsigned char PY_mb_me    []={"么麽"};
const unsigned char PY_mb_mei   []={"没每煤镁美酶妹枚霉玫眉梅寐昧媒糜媚谜沫嵋猸袂湄浼鹛莓魅镅楣"};
const unsigned char PY_mb_men   []={"门们闷扪焖懑钔"};
const unsigned char PY_mb_meng  []={"猛梦蒙锰孟盟檬萌氓礞蜢勐懵甍蠓虻朦艋艨瞢"};
const unsigned char PY_mb_mi    []={"米密迷眯蜜谜觅秘弥幂靡糜泌醚蘼縻咪汨麋祢猕弭谧芈脒宓敉嘧糸"};
const unsigned char PY_mb_mian  []={"面棉免绵眠缅勉冕娩腼湎眄沔黾渑"};
const unsigned char PY_mb_miao  []={"秒苗庙妙描瞄藐渺眇缪缈邈淼喵杪鹋"};
const unsigned char PY_mb_mie   []={"灭蔑咩篾蠛乜"};
const unsigned char PY_mb_min   []={"民抿敏闽皿悯珉愍缗闵玟苠泯黾鳘岷"};
const unsigned char PY_mb_ming  []={"名明命鸣铭螟盟冥瞑暝茗溟酩"};
const unsigned char PY_mb_miu   []={"谬缪"};
const unsigned char PY_mb_mo    []={"摸磨抹末膜墨没莫默魔模摩摹漠陌脉沫万无冒寞秣蓦麽茉嘿嬷蘑瘼殁镆嫫谟貊貘馍耱"};
const unsigned char PY_mb_mou   []={"某谋牟眸蛑鍪侔缪哞"};
const unsigned char PY_mb_mu    []={"木母亩幕目墓牧牟模穆暮牡拇募慕睦姆姥钼毪坶沐仫苜"};
const unsigned char PY_mb_na    []={"那拿哪纳钠娜呐南衲捺镎肭"};
const unsigned char PY_mb_nai   []={"乃耐奶奈氖哪萘艿柰鼐佴"};
const unsigned char PY_mb_nan   []={"难南男赧囡蝻楠喃腩"};
const unsigned char PY_mb_nang  []={"囊馕曩囔攮"};
const unsigned char PY_mb_nao   []={"闹脑恼挠淖孬铙瑙垴呶蛲猱硇"};
const unsigned char PY_mb_ne    []={"呢哪那呐讷"};
const unsigned char PY_mb_nei   []={"内哪馁那"};
const unsigned char PY_mb_nen   []={"嫩恁"};
const unsigned char PY_mb_neng  []={"能"};
const unsigned char PY_mb_ni    []={"你泥拟腻逆呢溺倪尼匿妮霓铌昵坭祢猊伲怩鲵睨旎"};
const unsigned char PY_mb_nian  []={"年念捻撵拈碾蔫粘廿黏辇鲇鲶埝"};
const unsigned char PY_mb_niang []={"娘酿"};
const unsigned char PY_mb_niao  []={"鸟尿袅茑脲嬲"};
const unsigned char PY_mb_nie   []={"捏镍聂孽涅镊啮陧蘖嗫臬蹑颞乜"};
const unsigned char PY_mb_nin   []={"您恁"};
const unsigned char PY_mb_ning  []={"拧凝宁柠狞泞佞甯咛聍"};
const unsigned char PY_mb_niu   []={"牛扭纽钮狃忸妞拗"};
const unsigned char PY_mb_nong  []={"弄浓农脓哝侬"};
const unsigned char PY_mb_nu    []={"怒努奴孥胬驽弩"};
const unsigned char PY_mb_nuan  []={"暖"};
const unsigned char PY_mb_nue   []={"虐疟谑"};
const unsigned char PY_mb_nuo   []={"挪诺懦糯娜喏傩锘搦"};
const unsigned char PY_mb_nv    []={"女钕恧衄"};
const unsigned char PY_mb_o     []={"哦喔噢"};
const unsigned char PY_mb_ou    []={"偶呕欧藕鸥区沤殴怄瓯讴耦"};
const unsigned char PY_mb_pa    []={"怕爬趴啪耙扒帕琶派筢杷葩"};
const unsigned char PY_mb_pai   []={"派排拍牌迫徘湃哌俳蒎"};
const unsigned char PY_mb_pan   []={"盘盼判攀畔潘叛磐番般胖襻蟠袢泮拚爿蹒"};
const unsigned char PY_mb_pang  []={"旁胖耪庞乓膀磅滂彷逄螃"};
const unsigned char PY_mb_pao   []={"跑抛炮泡刨袍咆狍匏庖疱脬"};
const unsigned char PY_mb_pei   []={"陪配赔呸胚佩培沛裴旆锫帔醅霈辔"};
const unsigned char PY_mb_pen   []={"喷盆湓"};
const unsigned char PY_mb_peng  []={"碰捧棚砰蓬朋彭鹏烹硼膨抨澎篷怦堋蟛嘭"};
const unsigned char PY_mb_pi    []={"批皮披匹劈辟坯屁脾僻疲痞霹琵毗啤譬砒否貔丕圮媲癖仳擗郫甓枇睥蜱鼙邳吡陂铍庀罴埤纰陴淠噼蚍裨"};
const unsigned char PY_mb_pian  []={"片篇骗偏便扁翩缏犏骈胼蹁谝"};
const unsigned char PY_mb_piao  []={"票飘漂瓢朴螵莩嫖瞟殍缥嘌骠剽"};
const unsigned char PY_mb_pie   []={"瞥撇苤氕"};
const unsigned char PY_mb_pin   []={"品贫聘拼频嫔榀姘牝颦"};
const unsigned char PY_mb_ping  []={"平凭瓶评屏乒萍苹坪冯娉鲆枰俜"};
const unsigned char PY_mb_po    []={"破坡颇婆泼迫泊魄朴繁粕笸皤钋陂鄱攴叵珀钷"};
const unsigned char PY_mb_pou   []={"剖掊裒"};
const unsigned char PY_mb_pu    []={"扑铺谱脯仆蒲葡朴菩曝莆瀑埔圃浦堡普暴镨噗匍溥濮氆蹼璞镤僕"};
const unsigned char PY_mb_qi    []={"起其七气期齐器妻骑汽棋奇欺漆启戚柒岂砌弃泣祁凄企乞契歧祈栖畦脐崎稽迄缉沏讫旗祺颀骐屺岐蹊萁蕲桤憩芪荠萋芑汔亟鳍俟槭嘁蛴綦亓欹琪麒琦蜞圻杞葺碛淇祗耆绮"};
const unsigned char PY_mb_qia   []={"恰卡掐洽袷葜髂"};
const unsigned char PY_mb_qian  []={"前钱千牵浅签欠铅嵌钎迁钳乾谴谦潜歉纤扦遣黔堑仟岍钤褰箝掮搴倩慊悭愆虔芡荨缱佥芊阡肷茜椠犍骞"};
const unsigned char PY_mb_qiang []={"强枪墙抢腔呛羌蔷将蜣跄戗襁戕炝镪锖锵羟樯嫱"};
const unsigned char PY_mb_qiao  []={"桥瞧敲巧翘锹壳鞘撬悄俏窍雀乔侨峭橇樵荞跷硗憔谯鞒愀缲诮劁"};
const unsigned char PY_mb_qie   []={"切且怯窃茄砌郄趄惬锲妾箧慊伽挈"};
const unsigned char PY_mb_qin   []={"亲琴侵勤擒寝秦芹沁禽钦吣覃矜衾芩溱廑嗪螓噙揿檎锓"};
const unsigned char PY_mb_qing  []={"请轻清青情晴氢倾庆擎顷亲卿氰圊謦檠箐苘蜻黥罄鲭磬綮"};
const unsigned char PY_mb_qiong []={"穷琼跫穹邛蛩茕銎筇"};
const unsigned char PY_mb_qiu   []={"求球秋丘泅仇邱囚酋龟楸蚯裘糗蝤巯逑俅虬赇鳅犰湫鼽遒"};
const unsigned char PY_mb_qu    []={"去取区娶渠曲趋趣屈驱蛆躯龋戌蠼蘧祛蕖磲劬诎鸲阒麴癯衢黢璩氍觑蛐朐瞿岖苣"};
const unsigned char PY_mb_quan  []={"全权劝圈拳犬泉券颧痊醛铨筌绻诠辁畎鬈悛蜷荃"};
const unsigned char PY_mb_que   []={"却缺确雀瘸鹊炔榷阙阕悫"};
const unsigned char PY_mb_qun   []={"群裙逡麇"};
const unsigned char PY_mb_ran   []={"染燃然冉髯苒蚺"};
const unsigned char PY_mb_rang  []={"让嚷瓤攘壤穰禳"};
const unsigned char PY_mb_rao   []={"饶绕扰荛桡娆"};
const unsigned char PY_mb_re    []={"热若惹喏"};
const unsigned char PY_mb_ren   []={"人任忍认刃仁韧妊纫壬饪轫仞荏葚衽稔"};
const unsigned char PY_mb_reng  []={"扔仍"};
const unsigned char PY_mb_ri    []={"日"};
const unsigned char PY_mb_rong  []={"容绒融溶熔荣戎蓉冗茸榕狨嵘肜蝾"};
const unsigned char PY_mb_rou   []={"肉揉柔糅蹂鞣"};
const unsigned char PY_mb_ru    []={"如入汝儒茹乳褥辱蠕孺蓐襦铷嚅缛濡薷颥溽洳"};
const unsigned char PY_mb_ruan  []={"软阮朊"};
const unsigned char PY_mb_rui   []={"瑞蕊锐睿芮蚋枘蕤"};
const unsigned char PY_mb_run   []={"闰润"};
const unsigned char PY_mb_ruo   []={"若弱偌箬"};
const unsigned char PY_mb_sa    []={"撒洒萨挲仨卅飒脎"};
const unsigned char PY_mb_sai   []={"塞腮鳃思赛噻"};
const unsigned char PY_mb_san   []={"三散伞叁馓糁毵霰"};
const unsigned char PY_mb_sang  []={"桑丧嗓颡磉搡"};
const unsigned char PY_mb_sao   []={"扫嫂搔骚梢埽鳋臊缫瘙"};
const unsigned char PY_mb_se    []={"色涩瑟塞啬铯穑"};
const unsigned char PY_mb_sen   []={"森"};
const unsigned char PY_mb_seng  []={"僧"};
const unsigned char PY_mb_sha   []={"杀沙啥纱傻砂刹莎厦煞杉嗄唼鲨霎铩痧裟挲歃"};
const unsigned char PY_mb_shai  []={"晒筛色酾"};
const unsigned char PY_mb_shan  []={"山闪衫善扇杉删煽单珊掺赡栅苫掸膳陕汕擅缮嬗蟮芟禅跚鄯潸鳝姗剡骟疝膻讪钐舢埏"};
const unsigned char PY_mb_shang []={"上伤尚商赏晌墒汤裳熵觞绱殇垧"};
const unsigned char PY_mb_shao  []={"少烧捎哨勺梢稍邵韶绍芍召鞘苕劭潲艄蛸筲"};
const unsigned char PY_mb_she   []={"社射蛇设舌摄舍折涉赊赦慑奢歙厍畲猞麝滠佘"};
const unsigned char PY_mb_shen  []={"身伸深婶神甚渗肾审申沈绅呻参砷什娠慎葚糁莘诜谂矧椹渖蜃哂胂"};
const unsigned char PY_mb_sheng []={"声省剩生升绳胜盛圣甥牲乘晟渑眚笙嵊"};
const unsigned char PY_mb_shi   []={"是使十时事室市石师试史式识虱矢拾屎驶始似嘘示士世柿匙拭誓逝势什殖峙嗜噬失适仕侍释饰氏狮食恃蚀视实施湿诗尸豕莳埘铈舐鲥鲺贳轼蓍筮炻谥弑酾螫"};
const unsigned char PY_mb_shou  []={"手受收首守瘦授兽售熟寿艏狩绶"};
const unsigned char PY_mb_shu   []={"书树数熟输梳叔属束术述蜀黍鼠淑赎孰蔬疏戍竖墅庶薯漱恕枢暑殊抒曙署舒姝摅秫"};
const unsigned char PY_mb_shua  []={"刷耍唰"};
const unsigned char PY_mb_shuai []={"摔甩率帅衰蟀"};
const unsigned char PY_mb_shuan []={"栓拴闩涮"};
const unsigned char PY_mb_shuang[]={"双霜爽泷孀"};
const unsigned char PY_mb_shui  []={"水谁睡税说"};
const unsigned char PY_mb_shun  []={"顺吮瞬舜"};
const unsigned char PY_mb_shuo  []={"说数硕烁朔搠妁槊蒴铄"};
const unsigned char PY_mb_si    []={"四死丝撕似私嘶思寺司斯食伺厕肆饲嗣巳耜驷兕蛳厮汜锶泗笥咝鸶姒厶缌祀澌俟"};
const unsigned char PY_mb_song  []={"送松耸宋颂诵怂讼竦菘淞悚嵩凇崧忪"};
const unsigned char PY_mb_sou   []={"艘搜擞嗽嗾嗖飕叟薮锼馊瞍溲螋擞"};
const unsigned char PY_mb_su    []={"素速诉塑宿俗苏肃粟酥缩溯僳愫簌觫稣夙嗉谡蔌涑"};
const unsigned char PY_mb_suan  []={"酸算蒜狻"};
const unsigned char PY_mb_sui   []={"岁随碎虽穗遂尿隋髓绥隧祟眭谇濉邃燧荽睢"};
const unsigned char PY_mb_sun   []={"孙损笋榫荪飧狲隼"};
const unsigned char PY_mb_suo   []={"所缩锁琐索梭蓑莎唆挲睃嗍唢桫嗦娑羧"};
const unsigned char PY_mb_ta    []={"他她它踏塔塌拓獭挞蹋溻趿鳎沓榻漯遢铊闼嗒"};
const unsigned char PY_mb_tai   []={"太抬台态胎苔泰酞汰炱肽跆呔鲐钛薹邰骀"};
const unsigned char PY_mb_tan   []={"谈叹探滩弹碳摊潭贪坛痰毯坦炭瘫谭坍檀袒郯昙忐钽锬澹镡覃"};
const unsigned char PY_mb_tang  []={"躺趟堂糖汤塘烫倘淌唐搪棠膛螳樘羰醣瑭镗傥饧溏耥帑铴螗"};
const unsigned char PY_mb_tao   []={"套掏逃桃讨淘涛滔陶绦萄鼗啕洮韬饕叨焘"};
const unsigned char PY_mb_te    []={"特忑慝铽忒"};
const unsigned char PY_mb_teng  []={"疼腾藤誊滕"};
const unsigned char PY_mb_ti    []={"提替体题踢蹄剃剔梯锑啼涕嚏惕屉醍鹈绨缇倜裼逖荑悌"};
const unsigned char PY_mb_tian  []={"天田添填甜舔恬腆佃掭钿阗忝殄畋"};
const unsigned char PY_mb_tiao  []={"条跳挑调迢眺龆笤祧蜩髫佻窕鲦苕粜"};
const unsigned char PY_mb_tie   []={"铁贴帖萜餮"};
const unsigned char PY_mb_ting  []={"听停挺厅亭艇庭廷烃汀莛葶婷梃蜓霆町铤"};
const unsigned char PY_mb_tong  []={"同通痛铜桶筒捅统童彤桐瞳恫侗酮潼茼仝砼峒恸佟嗵垌"};
const unsigned char PY_mb_tou   []={"头偷透投钭骰"};
const unsigned char PY_mb_tu    []={"土图兔涂吐秃突徒凸途屠堍荼菟钍酴"};
const unsigned char PY_mb_tuan  []={"团湍疃抟彖"};
const unsigned char PY_mb_tui   []={"腿推退褪颓蜕煺忒"};
const unsigned char PY_mb_tun   []={"吞屯褪臀囤氽饨暾豚"};
const unsigned char PY_mb_tuo   []={"拖脱托妥驮拓驼椭唾鸵陀魄乇佗坨庹沱柝柁橐跎箨酡砣鼍"};
const unsigned char PY_mb_wa    []={"挖瓦蛙哇娃洼凹袜佤娲腽"};
const unsigned char PY_mb_wai   []={"外歪崴"};
const unsigned char PY_mb_wan   []={"完万晚碗玩弯挽湾丸腕宛婉烷顽豌惋娩皖蔓莞脘蜿绾芄琬纨剜畹菀"};
const unsigned char PY_mb_wang  []={"望忘王往网亡枉旺汪妄芒罔惘辋魍"};
const unsigned char PY_mb_wei   []={"为位未围喂胃微味尾伪威伟卫危违委魏唯维畏惟韦巍蔚谓尉潍纬慰桅萎苇渭遗葳帏艉鲔娓逶闱隈沩玮涠帷崴隗诿洧偎猥猬嵬軎韪炜煨圩薇痿"};
const unsigned char PY_mb_wen   []={"问文闻稳温吻蚊纹瘟紊汶阌刎雯璺"};
const unsigned char PY_mb_weng  []={"翁嗡瓮蓊蕹"};
const unsigned char PY_mb_wo    []={"我握窝卧挝沃蜗涡斡倭幄龌肟莴喔渥硪"};
const unsigned char PY_mb_wu    []={"无五屋物舞雾误捂污悟勿钨武戊务呜伍吴午吾侮乌毋恶诬芜巫晤梧坞妩蜈牾寤兀怃阢邬忤骛於鋈仵杌鹜婺迕痦芴焐唔庑鹉鼯浯圬"};
const unsigned char PY_mb_xi    []={"西洗细吸戏系喜席稀溪熄锡膝息袭惜习嘻夕悉矽熙希檄牺晰昔媳硒铣烯腊析隙栖汐犀蜥奚浠葸饩屣玺嬉禊兮翕穸禧僖淅蓰舾蹊醯欷皙蟋羲茜徙隰郗唏曦螅歙樨阋粞熹觋菥鼷裼舄"};
const unsigned char PY_mb_xia   []={"下吓夏峡虾瞎霞狭匣侠辖厦暇唬狎遐瑕柙硖罅黠呷"};
const unsigned char PY_mb_xian  []={"先线县现显掀闲献嫌陷险鲜弦衔馅限咸锨仙腺贤纤宪舷涎羡铣见苋藓岘痫莶籼娴蚬猃祆冼燹跣跹酰暹氙鹇筅霰"};
const unsigned char PY_mb_xiang []={"想向象项响香乡相像箱巷享镶厢降翔祥橡详湘襄芗葙饷庠骧缃蟓鲞飨"};
const unsigned char PY_mb_xiao  []={"小笑消削销萧效宵晓肖孝硝啸霄哮嚣校骁哓潇逍枭绡淆崤箫枵筱魈蛸"};
const unsigned char PY_mb_xie   []={"写些鞋歇斜血谢卸挟屑蟹泻懈泄楔邪协械谐蝎携胁解契叶绁颉缬獬榭廨撷偕瀣渫亵榍邂薤躞燮勰"};
const unsigned char PY_mb_xin   []={"新心欣信芯薪锌辛寻衅忻歆囟莘馨鑫昕镡"};
const unsigned char PY_mb_xing  []={"性行型形星醒姓腥刑杏兴幸邢猩惺省硎悻荥陉擤荇"};
const unsigned char PY_mb_xiong []={"胸雄凶兄熊汹匈芎"};
const unsigned char PY_mb_xiu   []={"修锈绣休羞宿嗅袖秀朽臭咻岫馐庥溴鸺貅髹"};
const unsigned char PY_mb_xu    []={"许须需虚嘘蓄续序叙畜絮婿戌徐旭绪吁酗恤墟糈勖栩浒蓿顼圩洫胥醑诩溆煦盱砉"};
const unsigned char PY_mb_xuan  []={"选悬旋玄宣喧轩绚眩癣券儇炫谖萱揎泫渲漩璇楦暄煊碹铉镟痃"};
const unsigned char PY_mb_xue   []={"学雪血靴穴削薛踅噱鳕泶"};
const unsigned char PY_mb_xun   []={"寻讯熏训循殉旬巡迅驯汛逊勋荤询浚巽埙荀蕈薰峋徇獯恂洵浔曛醺鲟郇窨"};
const unsigned char PY_mb_ya    []={"呀压牙押芽鸭轧崖哑亚涯丫雅衙鸦讶蚜伢垭揠岈迓娅琊桠氩砑睚痖疋"};
const unsigned char PY_mb_yan   []={"眼烟沿盐言演严咽淹炎掩厌宴岩研延堰验艳阉砚雁唁彦焰蜒衍谚燕颜阎焉奄厣菸魇琰滟焱筵赝兖恹檐湮谳偃胭晏闫俨郾鄢妍崦嫣罨酽餍鼹铅殷阽芫阏腌剡"};
const unsigned char PY_mb_yang  []={"样养羊洋仰扬秧氧痒杨漾阳殃央鸯佯疡炀恙徉鞅泱蛘烊怏"};
const unsigned char PY_mb_yao   []={"要摇药咬腰窑舀邀妖谣遥姚瑶耀尧钥侥夭爻吆崾徭幺珧杳轺曜肴鹞窈鳐疟陶约铫"};
const unsigned char PY_mb_ye    []={"也夜业野叶爷页液掖腋冶噎耶咽曳椰邪谒邺晔烨揶铘靥"};
const unsigned char PY_mb_yi    []={"一以已亿衣移依易医乙仪亦椅益倚姨翼译伊蛇遗食艾胰疑沂宜异彝壹蚁谊揖铱矣翌艺抑绎邑蛾屹尾役臆逸肄疫颐裔意毅忆义夷溢诣议怿痍镒癔怡驿旖熠酏翊欹峄圯殪嗌咦懿噫劓诒饴漪佚咿瘗猗眙羿弈苡荑仡佾贻钇缢迤刈悒黟翳弋奕蜴埸挹嶷薏呓轶镱"};
const unsigned char PY_mb_yin   []={"因引印银音饮阴隐荫吟尹寅茵淫殷姻烟堙鄞喑夤胤龈吲圻狺垠霪蚓氤铟窨瘾洇茚"};
const unsigned char PY_mb_ying  []={"应硬影营迎映蝇赢鹰英颖莹盈婴樱缨荧萤萦楹蓥瘿茔鹦媵莺璎郢嘤撄瑛滢潆嬴罂瀛膺荥颍"};
const unsigned char PY_mb_yo    []={"哟育唷"};
const unsigned char PY_mb_yong  []={"用涌永拥蛹勇雍咏泳佣踊痈庸臃恿俑壅墉喁慵邕镛甬鳙饔"};
const unsigned char PY_mb_you   []={"有又由右油游幼优友铀忧尤犹诱悠邮酉佑幽釉攸卣侑莠莜莸呦囿宥柚猷牖铕疣蚰蚴蝣鱿黝鼬蝤繇"};
const unsigned char PY_mb_yu    []={"与于欲鱼雨余遇语愈狱玉渔予誉育愚羽虞娱淤舆屿禹宇迂俞逾域芋郁谷吁盂喻峪御愉粥渝尉榆隅浴寓裕预豫驭蔚妪嵛雩馀阈窬鹆妤揄窳觎臾舁龉蓣煜钰谀纡於竽瑜禺聿欤俣伛圄鹬庾昱萸瘐谕鬻圉瘀熨饫毓燠腴狳菀蜮蝓"};
const unsigned char PY_mb_yuan  []={"远员元院圆原愿园援猿怨冤源缘袁渊苑垣鸳辕圜鼋橼媛爰眢鸢掾芫沅瑗螈箢塬垸"};
const unsigned char PY_mb_yue   []={"月越约跃阅乐岳悦曰说粤钥瀹钺刖龠栎樾"};
const unsigned char PY_mb_yun   []={"云运晕允匀韵陨孕耘蕴酝郧员熨氲恽愠郓芸筠韫昀狁殒纭"};
const unsigned char PY_mb_za    []={"杂砸咋匝扎咱咂拶"};
const unsigned char PY_mb_zai   []={"在再灾载栽宰哉崽甾仔"};
const unsigned char PY_mb_zan   []={"咱暂攒赞簪趱糌瓒拶昝錾"};
const unsigned char PY_mb_zang  []={"脏葬赃藏臧驵奘"};
const unsigned char PY_mb_zao   []={"早造遭糟灶燥枣凿躁藻皂噪澡蚤唣"};
const unsigned char PY_mb_ze    []={"则责择泽咋侧箦舴帻迮啧仄昃笮赜"};
const unsigned char PY_mb_zei   []={"贼"};
const unsigned char PY_mb_zen   []={"怎谮"};
const unsigned char PY_mb_zeng  []={"增赠憎曾综缯罾甑锃"};
const unsigned char PY_mb_zha   []={"扎炸渣闸眨榨乍轧诈喳札铡揸吒咤哳猹砟痄蚱齄查蜡栅咋喋楂柞"};
const unsigned char PY_mb_zhai  []={"摘窄债斋寨择翟宅侧祭砦瘵"};
const unsigned char PY_mb_zhan  []={"站占战盏沾粘毡展栈詹颤蘸湛绽斩辗崭瞻谵搌旃"};
const unsigned char PY_mb_zhang []={"张章长帐仗丈掌涨账樟杖彰漳胀瘴障仉嫜幛鄣璋嶂獐蟑"};
const unsigned char PY_mb_zhao  []={"找着照招罩爪兆朝昭沼肇嘲召赵棹钊笊诏啁"};
const unsigned char PY_mb_zhe   []={"着这者折遮蛰哲蔗锗辙浙柘辄赭摺鹧磔褶蜇谪"};
const unsigned char PY_mb_zhen  []={"真阵镇针震枕振斟珍疹诊甄砧臻贞侦缜蓁祯箴轸榛稹赈朕鸩胗浈桢畛圳椹"};
const unsigned char PY_mb_zheng []={"正整睁争挣征怔证症郑拯蒸狰政帧峥钲铮筝诤徵丁鲭"};
const unsigned char PY_mb_zhi   []={"只之直知制指纸支芝枝稚吱蜘质肢脂汁炙织职痔植抵殖执值侄址智滞止趾治旨窒志挚掷至致置帜识峙氏秩帙摭黹桎枳轵忮祉蛭膣觯郅栀彘芷祗咫鸷絷踬胝骘轾痣陟踯雉埴贽卮酯豸跖栉伎"};
const unsigned char PY_mb_zhong []={"中重种钟肿众终盅忠仲衷踵舯螽锺冢忪"};
const unsigned char PY_mb_zhou  []={"周洲皱粥州轴舟昼骤宙诌肘帚咒繇胄纣荮啁碡绉籀妯酎"};
const unsigned char PY_mb_zhu   []={"住主猪竹株煮筑著珠蛛朱诸诛逐烛拄瞩嘱柱助蛀贮铸注祝驻伫潴洙瘃翥茱苎橥舳杼箸炷侏铢疰渚褚躅麈邾槠竺属术"};
const unsigned char PY_mb_zhua  []={"抓爪挝"};
const unsigned char PY_mb_zhuai []={"拽转"};
const unsigned char PY_mb_zhuan []={"转专砖赚传撰篆颛馔啭沌"};
const unsigned char PY_mb_zhuang[]={"装撞庄壮桩状幢妆僮奘戆"};
const unsigned char PY_mb_zhui  []={"追坠缀锥赘椎骓惴缒隹"};
const unsigned char PY_mb_zhun  []={"准谆屯肫窀"};
const unsigned char PY_mb_zhuo  []={"捉桌着啄拙灼浊卓琢缴茁酌擢焯濯诼浞涿倬镯禚斫"};
const unsigned char PY_mb_zi    []={"字自子紫籽资姿吱滓仔咨孜渍滋淄谘茈嵫姊孳缁梓辎赀恣眦锱秭耔笫粢趑訾龇鲻髭兹觜"};
const unsigned char PY_mb_zong  []={"总纵宗棕综踪鬃偬粽枞腙"};
const unsigned char PY_mb_zou   []={"走揍奏邹鲰鄹陬驺诹"};
const unsigned char PY_mb_zu    []={"组族足阻租祖诅菹镞卒俎"};
const unsigned char PY_mb_zuan  []={"钻纂赚攥缵躜"};
const unsigned char PY_mb_zui   []={"最嘴醉罪堆咀觜蕞"};
const unsigned char PY_mb_zun   []={"尊遵撙樽鳟"};
const unsigned char PY_mb_zuo   []={"做作坐左座昨凿佐阼唑怍胙祚撮琢嘬笮酢柞"};
const unsigned char PY_mb_bd    []={",.?!:;'\"()<>[]{}$%@*+-_=~`|/\\^&*"};
const unsigned char PY_mb_sz    []={"0123456789"}; //数字
const unsigned char PY_mb_abc   []={"abc"};
const unsigned char PY_mb_def   []={"def"};
const unsigned char PY_mb_ghi   []={"ghi"};
const unsigned char PY_mb_jkl   []={"jkl"}; 
const unsigned char PY_mb_mno   []={"mno"};
const unsigned char PY_mb_pqrs  []={"pqrs"}; 
const unsigned char PY_mb_tuv   []={"tuv"};
const unsigned char PY_mb_wxyz  []={"wxyz"}; 
const unsigned char PY_mb_ABC   []={"ABC"};
const unsigned char PY_mb_DEF   []={"DEF"};
const unsigned char PY_mb_GHI   []={"GHI"};
const unsigned char PY_mb_JKL   []={"JKL"}; 
const unsigned char PY_mb_MNO   []={"MNO"};
const unsigned char PY_mb_PQRS  []={"PQRS"}; 
const unsigned char PY_mb_TUV   []={"TUV"};
const unsigned char PY_mb_WXYZ  []={"WXYZ"};
#else


//const unsigned char PY_mb_space []={""};
const unsigned char PY_mb_space []={0x20,0x00};

//const unsigned char PY_mb_a     []={"啊阿呵吖嗄腌锕"};
const unsigned char PY_mb_a     []={0xb0,0xa1,0xb0,0xa2,0xba,0xc7,0xdf,0xb9,0xe0,0xc4,0xeb,0xe7,0xef,0xb9,0x00};

//const unsigned char PY_mb_ai    []={"爱矮挨哎碍癌艾唉哀蔼隘埃皑呆嗌嫒瑷暧捱砹嗳锿霭"};
const unsigned char PY_mb_ai    []={0xb0,0xae,0xb0,0xab,0xb0,0xa4,0xb0,0xa5,0xb0,0xad,0xb0,0xa9,0xb0,0xac,0xb0,0xa6,0xb0,0xa7,0xb0,0xaa,0xb0,0xaf,0xb0,0xa3,0xb0,0xa8,0xb4,0xf4,0xe0,0xc9,0xe6,0xc8,0xe8,0xa8,0xea,0xd3,0xde,0xdf,0xed,0xc1,0xe0,0xc8,0xef,0xcd,0xf6,0xb0,0x00};

//const unsigned char PY_mb_an    []={"按安暗岸俺案鞍氨胺厂广庵揞犴铵桉谙鹌埯黯"};
const unsigned char PY_mb_an    []={0xb0,0xb4,0xb0,0xb2,0xb0,0xb5,0xb0,0xb6,0xb0,0xb3,0xb0,0xb8,0xb0,0xb0,0xb0,0xb1,0xb0,0xb7,0xb3,0xa7,0xb9,0xe3,0xe2,0xd6,0xde,0xee,0xe1,0xed,0xef,0xa7,0xe8,0xf1,0xda,0xcf,0xf0,0xc6,0xdb,0xfb,0xf7,0xf6,0x00};

//const unsigned char PY_mb_ang   []={"昂肮盎仰"};
const unsigned char PY_mb_ang   []={0xb0,0xba,0xb0,0xb9,0xb0,0xbb,0xd1,0xf6,0x00};

//const unsigned char PY_mb_ao    []={"袄凹傲奥熬懊敖翱澳嚣拗媪廒骜嗷坳遨聱螯獒鏊鳌鏖"};
const unsigned char PY_mb_ao    []={0xb0,0xc0,0xb0,0xbc,0xb0,0xc1,0xb0,0xc2,0xb0,0xbe,0xb0,0xc3,0xb0,0xbd,0xb0,0xbf,0xb0,0xc4,0xcf,0xf9,0xde,0xd6,0xe6,0xc1,0xe2,0xda,0xe6,0xf1,0xe0,0xbb,0xdb,0xea,0xe5,0xdb,0xf1,0xfa,0xf2,0xfc,0xe9,0xe1,0xf6,0xcb,0xf7,0xa1,0xf7,0xe9,0x00};

//const unsigned char PY_mb_ba    []={"把八吧爸拔罢跋巴芭扒坝霸叭靶笆疤耙捌粑茇岜鲅钯魃"};
const unsigned char PY_mb_ba    []={0xb0,0xd1,0xb0,0xcb,0xb0,0xc9,0xb0,0xd6,0xb0,0xce,0xb0,0xd5,0xb0,0xcf,0xb0,0xcd,0xb0,0xc5,0xb0,0xc7,0xb0,0xd3,0xb0,0xd4,0xb0,0xc8,0xb0,0xd0,0xb0,0xca,0xb0,0xcc,0xb0,0xd2,0xb0,0xc6,0xf4,0xce,0xdc,0xd8,0xe1,0xb1,0xf6,0xd1,0xee,0xd9,0xf7,0xc9,0x00};

//const unsigned char PY_mb_bai   []={"百白摆败柏拜佰伯稗捭呗掰"};
const unsigned char PY_mb_bai   []={0xb0,0xd9,0xb0,0xd7,0xb0,0xda,0xb0,0xdc,0xb0,0xd8,0xb0,0xdd,0xb0,0xdb,0xb2,0xae,0xb0,0xde,0xde,0xe3,0xdf,0xc2,0xea,0xfe,0x00};

//const unsigned char PY_mb_ban   []={"半办班般拌搬版斑板伴扳扮瓣颁绊癍坂钣舨阪"};
const unsigned char PY_mb_ban   []={0xb0,0xeb,0xb0,0xec,0xb0,0xe0,0xb0,0xe3,0xb0,0xe8,0xb0,0xe1,0xb0,0xe6,0xb0,0xdf,0xb0,0xe5,0xb0,0xe9,0xb0,0xe2,0xb0,0xe7,0xb0,0xea,0xb0,0xe4,0xb0,0xed,0xf1,0xad,0xdb,0xe0,0xee,0xd3,0xf4,0xb2,0xda,0xe6,0x00};

//const unsigned char PY_mb_bang  []={"帮棒绑磅镑邦榜蚌傍梆膀谤浜蒡"};
const unsigned char PY_mb_bang  []={0xb0,0xef,0xb0,0xf4,0xb0,0xf3,0xb0,0xf5,0xb0,0xf7,0xb0,0xee,0xb0,0xf1,0xb0,0xf6,0xb0,0xf8,0xb0,0xf0,0xb0,0xf2,0xb0,0xf9,0xe4,0xba,0xdd,0xf2,0x00};

//const unsigned char PY_mb_bao   []={"包抱报饱保暴薄宝爆剥豹刨雹褒堡苞胞鲍炮瀑龅孢煲褓鸨趵葆"};
const unsigned char PY_mb_bao   []={0xb0,0xfc,0xb1,0xa7,0xb1,0xa8,0xb1,0xa5,0xb1,0xa3,0xb1,0xa9,0xb1,0xa1,0xb1,0xa6,0xb1,0xac,0xb0,0xfe,0xb1,0xaa,0xc5,0xd9,0xb1,0xa2,0xb0,0xfd,0xb1,0xa4,0xb0,0xfa,0xb0,0xfb,0xb1,0xab,0xc5,0xda,0xc6,0xd9,0xf6,0xb5,0xe6,0xdf,0xec,0xd2,0xf1,0xd9,0xf0,0xb1,0xf5,0xc0,0xdd,0xe1,0x00};

//const unsigned char PY_mb_bei   []={"被北倍杯背悲备碑卑贝辈钡焙狈惫臂褙悖蓓鹎鐾呗"};
const unsigned char PY_mb_bei   []={0xb1,0xbb,0xb1,0xb1,0xb1,0xb6,0xb1,0xad,0xb1,0xb3,0xb1,0xaf,0xb1,0xb8,0xb1,0xae,0xb1,0xb0,0xb1,0xb4,0xb1,0xb2,0xb1,0xb5,0xb1,0xba,0xb1,0xb7,0xb1,0xb9,0xb1,0xdb,0xf1,0xd8,0xe3,0xa3,0xdd,0xed,0xf0,0xc7,0xf6,0xcd,0xdf,0xc2,0x00};

//const unsigned char PY_mb_ben   []={"本奔苯笨夯锛贲畚坌"};
const unsigned char PY_mb_ben   []={0xb1,0xbe,0xb1,0xbc,0xb1,0xbd,0xb1,0xbf,0xba,0xbb,0xef,0xbc,0xea,0xda,0xdb,0xce,0xdb,0xd0,0x00};

//const unsigned char PY_mb_beng  []={"蹦绷甭崩迸蚌泵甏嘣"};
const unsigned char PY_mb_beng  []={0xb1,0xc4,0xb1,0xc1,0xb1,0xc2,0xb1,0xc0,0xb1,0xc5,0xb0,0xf6,0xb1,0xc3,0xea,0xb4,0xe0,0xd4,0x00};

//const unsigned char PY_mb_bi    []={"比笔闭鼻碧必避逼毕臂彼鄙壁蓖币弊辟蔽毙庇敝陛毖痹秘泌秕薜荸芘萆匕裨畀俾嬖狴筚箅篦舭荜襞庳铋跸吡愎贲滗濞璧哔髀弼妣婢"};
const unsigned char PY_mb_bi    []={0xb1,0xc8,0xb1,0xca,0xb1,0xd5,0xb1,0xc7,0xb1,0xcc,0xb1,0xd8,0xb1,0xdc,0xb1,0xc6,0xb1,0xcf,0xb1,0xdb,0xb1,0xcb,0xb1,0xc9,0xb1,0xda,0xb1,0xcd,0xb1,0xd2,0xb1,0xd7,0xb1,0xd9,0xb1,0xce,0xb1,0xd0,0xb1,0xd3,0xb1,0xd6,0xb1,0xdd,0xb1,0xd1,0xb1,0xd4,0xc3,0xd8,0xc3,0xda,0xef,0xf5,0xde,0xb5,0xdd,0xa9,0xdc,0xc5,0xdd,0xc9,0xd8,0xb0,0xf1,0xd4,0xee,0xaf,0xd9,0xc2,0xe6,0xd4,0xe1,0xf9,0xf3,0xd9,0xf3,0xeb,0xf3,0xf7,0xf4,0xb0,0xdc,0xea,0xf4,0xc5,0xe2,0xd8,0xee,0xe9,0xf5,0xcf,0xdf,0xc1,0xe3,0xb9,0xea,0xda,0xe4,0xe4,0xe5,0xa8,0xe8,0xb5,0xdf,0xd9,0xf7,0xc2,0xe5,0xf6,0xe5,0xfe,0xe6,0xbe,0x00};

//const unsigned char PY_mb_bian  []={"边变便遍编辩扁贬鞭卞辨辫忭砭匾汴碥蝙褊鳊笾苄窆弁缏"};
const unsigned char PY_mb_bian  []={0xb1,0xdf,0xb1,0xe4,0xb1,0xe3,0xb1,0xe9,0xb1,0xe0,0xb1,0xe7,0xb1,0xe2,0xb1,0xe1,0xb1,0xde,0xb1,0xe5,0xb1,0xe6,0xb1,0xe8,0xe2,0xed,0xed,0xbe,0xd8,0xd2,0xe3,0xea,0xed,0xdc,0xf2,0xf9,0xf1,0xdb,0xf6,0xfd,0xf3,0xd6,0xdc,0xd0,0xf1,0xb9,0xdb,0xcd,0xe7,0xc2,0x00};

//const unsigned char PY_mb_biao  []={"表标彪膘杓婊飑飙鳔瘭飚镳裱骠镖"};
const unsigned char PY_mb_biao  []={0xb1,0xed,0xb1,0xea,0xb1,0xeb,0xb1,0xec,0xe8,0xbc,0xe6,0xbb,0xec,0xa9,0xec,0xad,0xf7,0xa7,0xf1,0xa6,0xec,0xae,0xef,0xf0,0xf1,0xd1,0xe6,0xf4,0xef,0xda,0x00};

//const unsigned char PY_mb_bie   []={"别憋鳖瘪蹩"};
const unsigned char PY_mb_bie   []={0xb1,0xf0,0xb1,0xef,0xb1,0xee,0xb1,0xf1,0xf5,0xbf,0x00};

//const unsigned char PY_mb_bin   []={"宾濒摈彬斌滨豳膑殡缤髌傧槟鬓镔玢"};
const unsigned char PY_mb_bin   []={0xb1,0xf6,0xb1,0xf4,0xb1,0xf7,0xb1,0xf2,0xb1,0xf3,0xb1,0xf5,0xe1,0xd9,0xeb,0xf7,0xe9,0xeb,0xe7,0xcd,0xf7,0xc6,0xd9,0xcf,0xe9,0xc4,0xf7,0xde,0xef,0xd9,0xe7,0xe3,0x00};

//const unsigned char PY_mb_bing  []={"并病兵冰丙饼屏秉柄炳摒槟禀邴"};
const unsigned char PY_mb_bing  []={0xb2,0xa2,0xb2,0xa1,0xb1,0xf8,0xb1,0xf9,0xb1,0xfb,0xb1,0xfd,0xc6,0xc1,0xb1,0xfc,0xb1,0xfa,0xb1,0xfe,0xde,0xf0,0xe9,0xc4,0xd9,0xf7,0xda,0xfb,0x00};

//const unsigned char PY_mb_bo    []={"拨波播泊博伯驳玻剥薄勃菠钵搏脖帛般柏舶渤铂箔膊魄卜礴跛檗亳鹁踣啵蕃簸钹饽擘"};
const unsigned char PY_mb_bo    []={0xb2,0xa6,0xb2,0xa8,0xb2,0xa5,0xb2,0xb4,0xb2,0xa9,0xb2,0xae,0xb2,0xb5,0xb2,0xa3,0xb0,0xfe,0xb1,0xa1,0xb2,0xaa,0xb2,0xa4,0xb2,0xa7,0xb2,0xab,0xb2,0xb1,0xb2,0xaf,0xb0,0xe3,0xb0,0xd8,0xb2,0xb0,0xb2,0xb3,0xb2,0xac,0xb2,0xad,0xb2,0xb2,0xc6,0xc7,0xb2,0xb7,0xed,0xe7,0xf5,0xcb,0xe9,0xde,0xd9,0xf1,0xf0,0xbe,0xf5,0xdb,0xe0,0xa3,0xde,0xac,0xf4,0xa4,0xee,0xe0,0xe2,0xc4,0xeb,0xa2,0x00};

//const unsigned char PY_mb_bu    []={"不步补布部捕卜簿哺堡埠怖埔瓿逋晡钸钚醭卟"};
const unsigned char PY_mb_bu    []={0xb2,0xbb,0xb2,0xbd,0xb2,0xb9,0xb2,0xbc,0xb2,0xbf,0xb2,0xb6,0xb2,0xb7,0xb2,0xbe,0xb2,0xb8,0xb1,0xa4,0xb2,0xba,0xb2,0xc0,0xc6,0xd2,0xea,0xb3,0xe5,0xcd,0xea,0xce,0xee,0xdf,0xee,0xd0,0xf5,0xb3,0xdf,0xb2,0x00};

//const unsigned char PY_mb_ca    []={"擦拆礤嚓"};
const unsigned char PY_mb_ca    []={0xb2,0xc1,0xb2,0xf0,0xed,0xe5,0xe0,0xea,0x00};

//const unsigned char PY_mb_cai   []={"猜才材财裁采彩睬踩菜蔡"};
const unsigned char PY_mb_cai   []={0xb2,0xc2,0xb2,0xc5,0xb2,0xc4,0xb2,0xc6,0xb2,0xc3,0xb2,0xc9,0xb2,0xca,0xb2,0xc7,0xb2,0xc8,0xb2,0xcb,0xb2,0xcc,0x00};

//const unsigned char PY_mb_can   []={"蚕残掺参惨惭餐灿骖璨孱黪粲"};
const unsigned char PY_mb_can   []={0xb2,0xcf,0xb2,0xd0,0xb2,0xf4,0xb2,0xce,0xb2,0xd2,0xb2,0xd1,0xb2,0xcd,0xb2,0xd3,0xe6,0xee,0xe8,0xb2,0xe5,0xee,0xf7,0xf5,0xf4,0xd3,0x00};

//const unsigned char PY_mb_cang  []={"藏仓沧舱苍伧"};
const unsigned char PY_mb_cang  []={0xb2,0xd8,0xb2,0xd6,0xb2,0xd7,0xb2,0xd5,0xb2,0xd4,0xd8,0xf7,0x00};

//const unsigned char PY_mb_cao   []={"草操曹槽糙嘈艚螬漕"};
const unsigned char PY_mb_cao   []={0xb2,0xdd,0xb2,0xd9,0xb2,0xdc,0xb2,0xdb,0xb2,0xda,0xe0,0xd0,0xf4,0xbd,0xf3,0xa9,0xe4,0xee,0x00};

//const unsigned char PY_mb_ce    []={"册侧策测厕恻"};
const unsigned char PY_mb_ce    []={0xb2,0xe1,0xb2,0xe0,0xb2,0xdf,0xb2,0xe2,0xb2,0xde,0xe2,0xfc,0x00};

//const unsigned char PY_mb_cen   []={"参岑涔"};
const unsigned char PY_mb_cen   []={0xb2,0xce,0xe1,0xaf,0xe4,0xb9,0x00};

//const unsigned char PY_mb_ceng  []={"曾层蹭噌"};
const unsigned char PY_mb_ceng  []={0xd4,0xf8,0xb2,0xe3,0xb2,0xe4,0xe0,0xe1,0x00};

//const unsigned char PY_mb_cha   []={"查插叉茶差岔搽察茬碴刹诧楂槎镲衩汊馇檫姹杈锸嚓"};
const unsigned char PY_mb_cha   []={0xb2,0xe9,0xb2,0xe5,0xb2,0xe6,0xb2,0xe8,0xb2,0xee,0xb2,0xed,0xb2,0xeb,0xb2,0xec,0xb2,0xe7,0xb2,0xea,0xc9,0xb2,0xb2,0xef,0xe9,0xab,0xe9,0xb6,0xef,0xef,0xf1,0xc3,0xe3,0xe2,0xe2,0xc7,0xe9,0xdf,0xe6,0xb1,0xe8,0xbe,0xef,0xca,0xe0,0xea,0x00};

//const unsigned char PY_mb_chai  []={"菜柴拆差豺钗瘥虿侪"};
const unsigned char PY_mb_chai  []={0xb2,0xcb,0xb2,0xf1,0xb2,0xf0,0xb2,0xee,0xb2,0xf2,0xee,0xce,0xf0,0xfb,0xf2,0xb2,0xd9,0xad,0x00};

//const unsigned char PY_mb_chan  []={"产缠掺搀阐颤铲谗蝉单馋觇婵蒇谄冁廛孱蟾羼镡忏潺禅骣躔澶"};
const unsigned char PY_mb_chan  []={0xb2,0xfa,0xb2,0xf8,0xb2,0xf4,0xb2,0xf3,0xb2,0xfb,0xb2,0xfc,0xb2,0xf9,0xb2,0xf7,0xb2,0xf5,0xb5,0xa5,0xb2,0xf6,0xea,0xe8,0xe6,0xbf,0xdd,0xdb,0xda,0xc6,0xd9,0xe6,0xe2,0xdc,0xe5,0xee,0xf3,0xb8,0xe5,0xf1,0xef,0xe2,0xe2,0xe3,0xe4,0xfd,0xec,0xf8,0xe6,0xf6,0xf5,0xf0,0xe5,0xa4,0x00};

//const unsigned char PY_mb_chang []={"长唱常场厂尝肠畅昌敞倡偿猖裳鲳氅菖惝嫦徜鬯阊怅伥昶苌娼"};
const unsigned char PY_mb_chang []={0xb3,0xa4,0xb3,0xaa,0xb3,0xa3,0xb3,0xa1,0xb3,0xa7,0xb3,0xa2,0xb3,0xa6,0xb3,0xa9,0xb2,0xfd,0xb3,0xa8,0xb3,0xab,0xb3,0xa5,0xb2,0xfe,0xc9,0xd1,0xf6,0xf0,0xeb,0xa9,0xdd,0xc5,0xe3,0xae,0xe6,0xcf,0xe1,0xe4,0xdb,0xcb,0xe3,0xd1,0xe2,0xea,0xd8,0xf6,0xea,0xc6,0xdc,0xc9,0xe6,0xbd,0x00};

//const unsigned char PY_mb_chao  []={"朝抄超吵潮巢炒嘲剿绰钞怊焯耖晁"};
const unsigned char PY_mb_chao  []={0xb3,0xaf,0xb3,0xad,0xb3,0xac,0xb3,0xb3,0xb3,0xb1,0xb3,0xb2,0xb3,0xb4,0xb3,0xb0,0xbd,0xcb,0xb4,0xc2,0xb3,0xae,0xe2,0xf7,0xec,0xcc,0xf1,0xe9,0xea,0xcb,0x00};

//const unsigned char PY_mb_che   []={"车撤扯掣彻尺澈坼砗"};
const unsigned char PY_mb_che   []={0xb3,0xb5,0xb3,0xb7,0xb3,0xb6,0xb3,0xb8,0xb3,0xb9,0xb3,0xdf,0xb3,0xba,0xdb,0xe5,0xed,0xba,0x00};

//const unsigned char PY_mb_chen  []={"趁称辰臣尘晨沉陈衬橙忱郴榇抻谌碜谶宸龀嗔伧琛"};
const unsigned char PY_mb_chen  []={0xb3,0xc3,0xb3,0xc6,0xb3,0xbd,0xb3,0xbc,0xb3,0xbe,0xb3,0xbf,0xb3,0xc1,0xb3,0xc2,0xb3,0xc4,0xb3,0xc8,0xb3,0xc0,0xb3,0xbb,0xe9,0xb4,0xde,0xd3,0xda,0xc8,0xed,0xd7,0xda,0xdf,0xe5,0xb7,0xf6,0xb3,0xe0,0xc1,0xd8,0xf7,0xe8,0xa1,0x00};

//const unsigned char PY_mb_cheng []={"成乘盛撑称城程呈诚惩逞骋澄橙承塍柽埕铖噌铛酲晟裎枨蛏丞瞠"};
const unsigned char PY_mb_cheng []={0xb3,0xc9,0xb3,0xcb,0xca,0xa2,0xb3,0xc5,0xb3,0xc6,0xb3,0xc7,0xb3,0xcc,0xb3,0xca,0xb3,0xcf,0xb3,0xcd,0xb3,0xd1,0xb3,0xd2,0xb3,0xce,0xb3,0xc8,0xb3,0xd0,0xeb,0xf3,0xe8,0xdf,0xdb,0xf4,0xee,0xf1,0xe0,0xe1,0xee,0xf5,0xf5,0xa8,0xea,0xc9,0xf1,0xce,0xe8,0xc7,0xf2,0xc9,0xd8,0xa9,0xee,0xaa,0x00};

//const unsigned char PY_mb_chi   []={"吃尺迟池翅痴赤齿耻持斥侈弛驰炽匙踟坻茌墀饬媸豉褫敕哧瘛蚩啻鸱眵螭篪魑叱彳笞嗤"};
const unsigned char PY_mb_chi   []={0xb3,0xd4,0xb3,0xdf,0xb3,0xd9,0xb3,0xd8,0xb3,0xe1,0xb3,0xd5,0xb3,0xe0,0xb3,0xdd,0xb3,0xdc,0xb3,0xd6,0xb3,0xe2,0xb3,0xde,0xb3,0xda,0xb3,0xdb,0xb3,0xe3,0xb3,0xd7,0xf5,0xd8,0xdb,0xe6,0xdc,0xdd,0xdc,0xaf,0xe2,0xc1,0xe6,0xca,0xf4,0xf9,0xf1,0xdd,0xeb,0xb7,0xdf,0xea,0xf1,0xa1,0xf2,0xbf,0xe0,0xb4,0xf0,0xb7,0xed,0xf7,0xf3,0xa4,0xf3,0xf8,0xf7,0xce,0xdf,0xb3,0xe1,0xdc,0xf3,0xd7,0xe0,0xcd,0x00};

//const unsigned char PY_mb_chong []={"冲重虫充宠崇涌种艟忡舂铳憧茺"};
const unsigned char PY_mb_chong []={0xb3,0xe5,0xd6,0xd8,0xb3,0xe6,0xb3,0xe4,0xb3,0xe8,0xb3,0xe7,0xd3,0xbf,0xd6,0xd6,0xf4,0xbe,0xe2,0xe7,0xf4,0xa9,0xef,0xa5,0xe3,0xbf,0xdc,0xfb,0x00};

//const unsigned char PY_mb_chou  []={"抽愁臭仇丑稠绸酬筹踌畴瞅惆俦帱瘳雠"};
const unsigned char PY_mb_chou  []={0xb3,0xe9,0xb3,0xee,0xb3,0xf4,0xb3,0xf0,0xb3,0xf3,0xb3,0xed,0xb3,0xf1,0xb3,0xea,0xb3,0xef,0xb3,0xec,0xb3,0xeb,0xb3,0xf2,0xe3,0xb0,0xd9,0xb1,0xe0,0xfc,0xf1,0xac,0xf6,0xc5,0x00};

//const unsigned char PY_mb_chu   []={"出处初锄除触橱楚础储畜滁矗搐躇厨雏楮杵刍怵绌亍憷蹰黜蜍樗"};
const unsigned char PY_mb_chu   []={0xb3,0xf6,0xb4,0xa6,0xb3,0xf5,0xb3,0xfa,0xb3,0xfd,0xb4,0xa5,0xb3,0xf7,0xb3,0xfe,0xb4,0xa1,0xb4,0xa2,0xd0,0xf3,0xb3,0xfc,0xb4,0xa3,0xb4,0xa4,0xb3,0xf9,0xb3,0xf8,0xb3,0xfb,0xe8,0xfa,0xe8,0xc6,0xdb,0xbb,0xe2,0xf0,0xe7,0xa9,0xd8,0xa1,0xe3,0xc0,0xf5,0xe9,0xf7,0xed,0xf2,0xdc,0xe9,0xcb,0x00};

//const unsigned char PY_mb_chuai []={"揣膪啜嘬搋踹"};
const unsigned char PY_mb_chuai []={0xb4,0xa7,0xeb,0xfa,0xe0,0xa8,0xe0,0xdc,0xde,0xf5,0xf5,0xdf,0x00};

//const unsigned char PY_mb_chuan []={"穿船传串川喘椽氚遄钏舡舛巛"};
const unsigned char PY_mb_chuan []={0xb4,0xa9,0xb4,0xac,0xb4,0xab,0xb4,0xae,0xb4,0xa8,0xb4,0xad,0xb4,0xaa,0xeb,0xb0,0xe5,0xd7,0xee,0xcb,0xf4,0xad,0xe2,0xb6,0xe7,0xdd,0x00};

//const unsigned char PY_mb_chuang[]={"窗床闯创疮幢怆"};
const unsigned char PY_mb_chuang[]={0xb4,0xb0,0xb4,0xb2,0xb4,0xb3,0xb4,0xb4,0xb4,0xaf,0xb4,0xb1,0xe2,0xeb,0x00};

//const unsigned char PY_mb_chui  []={"吹垂炊锤捶椎槌棰陲"};
const unsigned char PY_mb_chui  []={0xb4,0xb5,0xb4,0xb9,0xb4,0xb6,0xb4,0xb8,0xb4,0xb7,0xd7,0xb5,0xe9,0xb3,0xe9,0xa2,0xda,0xef,0x00};

//const unsigned char PY_mb_chun  []={"春唇纯蠢醇淳椿蝽莼鹑"};
const unsigned char PY_mb_chun  []={0xb4,0xba,0xb4,0xbd,0xb4,0xbf,0xb4,0xc0,0xb4,0xbc,0xb4,0xbe,0xb4,0xbb,0xf2,0xed,0xdd,0xbb,0xf0,0xc8,0x00};

//const unsigned char PY_mb_chuo  []={"戳绰踔啜龊辍"};
const unsigned char PY_mb_chuo  []={0xb4,0xc1,0xb4,0xc2,0xf5,0xd6,0xe0,0xa8,0xf6,0xba,0xea,0xa1,0x00};

//const unsigned char PY_mb_ci    []={"次此词瓷慈雌磁辞刺茨伺疵赐差兹呲鹚祠糍"};
const unsigned char PY_mb_ci    []={0xb4,0xce,0xb4,0xcb,0xb4,0xca,0xb4,0xc9,0xb4,0xc8,0xb4,0xc6,0xb4,0xc5,0xb4,0xc7,0xb4,0xcc,0xb4,0xc4,0xcb,0xc5,0xb4,0xc3,0xb4,0xcd,0xb2,0xee,0xd7,0xc8,0xdf,0xda,0xf0,0xcb,0xec,0xf4,0xf4,0xd9,0x00};

//const unsigned char PY_mb_cong  []={"从丛葱匆聪囱琮枞淙璁骢苁"};
const unsigned char PY_mb_cong  []={0xb4,0xd3,0xb4,0xd4,0xb4,0xd0,0xb4,0xd2,0xb4,0xcf,0xb4,0xd1,0xe7,0xfd,0xe8,0xc8,0xe4,0xc8,0xe8,0xae,0xe6,0xf5,0xdc,0xca,0x00};

//const unsigned char PY_mb_cou   []={"凑楱辏腠"};
const unsigned char PY_mb_cou   []={0xb4,0xd5,0xe9,0xa8,0xea,0xa3,0xeb,0xed,0x00};

//const unsigned char PY_mb_cu    []={"粗醋簇促卒徂猝蔟蹙酢殂蹴"};
const unsigned char PY_mb_cu    []={0xb4,0xd6,0xb4,0xd7,0xb4,0xd8,0xb4,0xd9,0xd7,0xe4,0xe1,0xde,0xe2,0xa7,0xdd,0xfd,0xf5,0xbe,0xf5,0xa1,0xe9,0xe3,0xf5,0xed,0x00};

//const unsigned char PY_mb_cuan  []={"窜蹿篡攒撺汆爨镩"};
const unsigned char PY_mb_cuan  []={0xb4,0xdc,0xb4,0xda,0xb4,0xdb,0xd4,0xdc,0xdf,0xa5,0xd9,0xe0,0xec,0xe0,0xef,0xe9,0x00};

//const unsigned char PY_mb_cui   []={"催脆摧翠崔淬衰瘁粹璀啐悴萃毳榱"};
const unsigned char PY_mb_cui   []={0xb4,0xdf,0xb4,0xe0,0xb4,0xdd,0xb4,0xe4,0xb4,0xde,0xb4,0xe3,0xcb,0xa5,0xb4,0xe1,0xb4,0xe2,0xe8,0xad,0xdf,0xfd,0xe3,0xb2,0xdd,0xcd,0xeb,0xa5,0xe9,0xc1,0x00};

//const unsigned char PY_mb_cun   []={"村寸存蹲忖皴"};
const unsigned char PY_mb_cun   []={0xb4,0xe5,0xb4,0xe7,0xb4,0xe6,0xb6,0xd7,0xe2,0xe2,0xf1,0xe5,0x00};

//const unsigned char PY_mb_cuo   []={"错撮搓挫措磋嵯厝鹾脞痤蹉瘥锉矬"};
const unsigned char PY_mb_cuo   []={0xb4,0xed,0xb4,0xe9,0xb4,0xea,0xb4,0xec,0xb4,0xeb,0xb4,0xe8,0xe1,0xcf,0xd8,0xc8,0xf5,0xba,0xeb,0xe2,0xf0,0xee,0xf5,0xe3,0xf0,0xfb,0xef,0xb1,0xef,0xf3,0x00};

//const unsigned char PY_mb_da    []={"大答达打搭瘩塔笪耷哒褡疸怛靼妲沓嗒鞑"};
const unsigned char PY_mb_da    []={0xb4,0xf3,0xb4,0xf0,0xb4,0xef,0xb4,0xf2,0xb4,0xee,0xb4,0xf1,0xcb,0xfe,0xf3,0xce,0xde,0xc7,0xdf,0xd5,0xf1,0xd7,0xf0,0xe3,0xe2,0xf2,0xf7,0xb0,0xe6,0xa7,0xed,0xb3,0xe0,0xaa,0xf7,0xb2,0x00};

//const unsigned char PY_mb_dai   []={"带代呆戴待袋逮歹贷怠傣大殆呔玳迨岱甙黛骀绐埭"};
const unsigned char PY_mb_dai   []={0xb4,0xf8,0xb4,0xfa,0xb4,0xf4,0xb4,0xf7,0xb4,0xfd,0xb4,0xfc,0xb4,0xfe,0xb4,0xf5,0xb4,0xfb,0xb5,0xa1,0xb4,0xf6,0xb4,0xf3,0xb4,0xf9,0xdf,0xbe,0xe7,0xe9,0xe5,0xca,0xe1,0xb7,0xdf,0xb0,0xf7,0xec,0xe6,0xe6,0xe7,0xaa,0xdc,0xa4,0x00};

//const unsigned char PY_mb_dan   []={"但单蛋担弹掸胆淡丹耽旦氮诞郸惮石疸澹瘅萏殚眈聃箪赕儋啖"};
const unsigned char PY_mb_dan   []={0xb5,0xab,0xb5,0xa5,0xb5,0xb0,0xb5,0xa3,0xb5,0xaf,0xb5,0xa7,0xb5,0xa8,0xb5,0xad,0xb5,0xa4,0xb5,0xa2,0xb5,0xa9,0xb5,0xaa,0xb5,0xae,0xb5,0xa6,0xb5,0xac,0xca,0xaf,0xf0,0xe3,0xe5,0xa3,0xf0,0xf7,0xdd,0xcc,0xe9,0xe9,0xed,0xf1,0xf1,0xf5,0xf3,0xec,0xea,0xe6,0xd9,0xd9,0xe0,0xa2,0x00};

//const unsigned char PY_mb_dang  []={"当党挡档荡谠铛宕菪凼裆砀"};
const unsigned char PY_mb_dang  []={0xb5,0xb1,0xb5,0xb3,0xb5,0xb2,0xb5,0xb5,0xb5,0xb4,0xda,0xd4,0xee,0xf5,0xe5,0xb4,0xdd,0xd0,0xdb,0xca,0xf1,0xc9,0xed,0xb8,0x00};

//const unsigned char PY_mb_dao   []={"到道倒刀岛盗稻捣悼导蹈祷帱纛忉焘氘叨"};
const unsigned char PY_mb_dao   []={0xb5,0xbd,0xb5,0xc0,0xb5,0xb9,0xb5,0xb6,0xb5,0xba,0xb5,0xc1,0xb5,0xbe,0xb5,0xb7,0xb5,0xbf,0xb5,0xbc,0xb5,0xb8,0xb5,0xbb,0xe0,0xfc,0xf4,0xee,0xe2,0xe1,0xec,0xe2,0xeb,0xae,0xdf,0xb6,0x00};

//const unsigned char PY_mb_de    []={"的地得德底锝"};
const unsigned char PY_mb_de    []={0xb5,0xc4,0xb5,0xd8,0xb5,0xc3,0xb5,0xc2,0xb5,0xd7,0xef,0xbd,0x00};

//const unsigned char PY_mb_deng  []={"等灯邓登澄瞪凳蹬磴镫噔嶝戥簦"};
const unsigned char PY_mb_deng  []={0xb5,0xc8,0xb5,0xc6,0xb5,0xcb,0xb5,0xc7,0xb3,0xce,0xb5,0xc9,0xb5,0xca,0xb5,0xc5,0xed,0xe3,0xef,0xeb,0xe0,0xe2,0xe1,0xd8,0xea,0xad,0xf4,0xa3,0x00};

//const unsigned char PY_mb_di    []={"地第底低敌抵滴帝递嫡弟缔堤的涤提笛迪狄翟蒂觌邸谛诋嘀柢骶羝氐棣睇娣荻碲镝坻籴砥"};
const unsigned char PY_mb_di    []={0xb5,0xd8,0xb5,0xda,0xb5,0xd7,0xb5,0xcd,0xb5,0xd0,0xb5,0xd6,0xb5,0xce,0xb5,0xdb,0xb5,0xdd,0xb5,0xd5,0xb5,0xdc,0xb5,0xde,0xb5,0xcc,0xb5,0xc4,0xb5,0xd3,0xcc,0xe1,0xb5,0xd1,0xb5,0xcf,0xb5,0xd2,0xb5,0xd4,0xb5,0xd9,0xea,0xeb,0xdb,0xa1,0xda,0xd0,0xda,0xae,0xe0,0xd6,0xe8,0xdc,0xf7,0xbe,0xf4,0xc6,0xd8,0xb5,0xe9,0xa6,0xed,0xfb,0xe6,0xb7,0xdd,0xb6,0xed,0xda,0xef,0xe1,0xdb,0xe6,0xd9,0xe1,0xed,0xc6,0x00};

//const unsigned char PY_mb_dia	[]={"嗲"};
const unsigned char PY_mb_dia	[]={0xe0,0xc7,0x00};

//const unsigned char PY_mb_dian  []={"点电店殿淀掂颠垫碘惦奠典佃靛滇甸踮钿坫阽癫簟玷巅癜"};
const unsigned char PY_mb_dian  []={0xb5,0xe3,0xb5,0xe7,0xb5,0xea,0xb5,0xee,0xb5,0xed,0xb5,0xe0,0xb5,0xdf,0xb5,0xe6,0xb5,0xe2,0xb5,0xeb,0xb5,0xec,0xb5,0xe4,0xb5,0xe8,0xb5,0xe5,0xb5,0xe1,0xb5,0xe9,0xf5,0xda,0xee,0xe4,0xdb,0xe3,0xda,0xe7,0xf1,0xb2,0xf4,0xa1,0xe7,0xe8,0xe1,0xdb,0xf1,0xb0,0x00};

//const unsigned char PY_mb_diao  []={"掉钓叼吊雕调刁碉凋鸟铞铫鲷貂"};
const unsigned char PY_mb_diao  []={0xb5,0xf4,0xb5,0xf6,0xb5,0xf0,0xb5,0xf5,0xb5,0xf1,0xb5,0xf7,0xb5,0xf3,0xb5,0xef,0xb5,0xf2,0xc4,0xf1,0xee,0xf6,0xef,0xa2,0xf6,0xf4,0xf5,0xf5,0x00};

//const unsigned char PY_mb_die   []={"爹跌叠碟蝶迭谍牒堞瓞揲蹀耋鲽垤喋"};
const unsigned char PY_mb_die   []={0xb5,0xf9,0xb5,0xf8,0xb5,0xfe,0xb5,0xfa,0xb5,0xfb,0xb5,0xfc,0xb5,0xfd,0xeb,0xba,0xdc,0xa6,0xf0,0xac,0xde,0xe9,0xf5,0xde,0xf1,0xf3,0xf6,0xf8,0xdb,0xec,0xe0,0xa9,0x00};

//const unsigned char PY_mb_ding  []={"顶定盯订叮丁钉鼎锭町玎铤腚碇疔仃耵酊啶"};
const unsigned char PY_mb_ding  []={0xb6,0xa5,0xb6,0xa8,0xb6,0xa2,0xb6,0xa9,0xb6,0xa3,0xb6,0xa1,0xb6,0xa4,0xb6,0xa6,0xb6,0xa7,0xee,0xae,0xe7,0xe0,0xee,0xfa,0xeb,0xeb,0xed,0xd6,0xf0,0xdb,0xd8,0xea,0xf1,0xf4,0xf4,0xfa,0xe0,0xa4,0x00};

//const unsigned char PY_mb_diu   []={"丢铥"};
const unsigned char PY_mb_diu   []={0xb6,0xaa,0xee,0xfb,0x00};

//const unsigned char PY_mb_dong  []={"动东懂洞冻冬董栋侗恫峒鸫垌胨胴硐氡岽咚"};
const unsigned char PY_mb_dong  []={0xb6,0xaf,0xb6,0xab,0xb6,0xae,0xb6,0xb4,0xb6,0xb3,0xb6,0xac,0xb6,0xad,0xb6,0xb0,0xb6,0xb1,0xb6,0xb2,0xe1,0xbc,0xf0,0xb4,0xdb,0xed,0xeb,0xcb,0xeb,0xd8,0xed,0xcf,0xeb,0xb1,0xe1,0xb4,0xdf,0xcb,0x00};

//const unsigned char PY_mb_dou   []={"都斗豆逗陡抖痘兜读蚪窦篼蔸"};
const unsigned char PY_mb_dou   []={0xb6,0xbc,0xb6,0xb7,0xb6,0xb9,0xb6,0xba,0xb6,0xb8,0xb6,0xb6,0xb6,0xbb,0xb6,0xb5,0xb6,0xc1,0xf2,0xbd,0xf1,0xbc,0xf3,0xfb,0xdd,0xfa,0x00};

//const unsigned char PY_mb_du    []={"读度毒渡堵独肚镀赌睹杜督都犊妒顿蠹笃嘟渎椟牍黩髑芏"};
const unsigned char PY_mb_du    []={0xb6,0xc1,0xb6,0xc8,0xb6,0xbe,0xb6,0xc9,0xb6,0xc2,0xb6,0xc0,0xb6,0xc7,0xb6,0xc6,0xb6,0xc4,0xb6,0xc3,0xb6,0xc5,0xb6,0xbd,0xb6,0xbc,0xb6,0xbf,0xb6,0xca,0xb6,0xd9,0xf3,0xbc,0xf3,0xc6,0xe0,0xbd,0xe4,0xc2,0xe8,0xfc,0xeb,0xb9,0xf7,0xf2,0xf7,0xc7,0xdc,0xb6,0x00};

//const unsigned char PY_mb_duan  []={"段短断端锻缎椴煅簖"};
const unsigned char PY_mb_duan  []={0xb6,0xce,0xb6,0xcc,0xb6,0xcf,0xb6,0xcb,0xb6,0xcd,0xb6,0xd0,0xe9,0xb2,0xec,0xd1,0xf3,0xfd,0x00};

//const unsigned char PY_mb_dui   []={"对队堆兑敦镦碓怼憝"};
const unsigned char PY_mb_dui   []={0xb6,0xd4,0xb6,0xd3,0xb6,0xd1,0xb6,0xd2,0xb6,0xd8,0xef,0xe6,0xed,0xd4,0xed,0xa1,0xed,0xad,0x00};

//const unsigned char PY_mb_dun   []={"吨顿蹲墩敦钝盾囤遁不趸沌盹镦礅炖砘"};
const unsigned char PY_mb_dun   []={0xb6,0xd6,0xb6,0xd9,0xb6,0xd7,0xb6,0xd5,0xb6,0xd8,0xb6,0xdb,0xb6,0xdc,0xb6,0xda,0xb6,0xdd,0xb2,0xbb,0xf5,0xbb,0xe3,0xe7,0xed,0xef,0xef,0xe6,0xed,0xe2,0xec,0xc0,0xed,0xbb,0x00};

//const unsigned char PY_mb_duo   []={"多朵夺舵剁垛跺惰堕掇哆驮度躲踱沲咄铎裰哚缍"};
const unsigned char PY_mb_duo   []={0xb6,0xe0,0xb6,0xe4,0xb6,0xe1,0xb6,0xe6,0xb6,0xe7,0xb6,0xe2,0xb6,0xe5,0xb6,0xe8,0xb6,0xe9,0xb6,0xde,0xb6,0xdf,0xcd,0xd4,0xb6,0xc8,0xb6,0xe3,0xf5,0xe2,0xe3,0xf5,0xdf,0xcd,0xee,0xec,0xf1,0xd6,0xdf,0xe1,0xe7,0xb6,0x00};

//const unsigned char PY_mb_e     []={"饿哦额鹅蛾扼俄讹阿遏峨娥恶厄鄂锇谔垩锷阏萼苊轭婀莪鳄颚腭愕呃噩鹗屙"};
const unsigned char PY_mb_e     []={0xb6,0xf6,0xc5,0xb6,0xb6,0xee,0xb6,0xec,0xb6,0xea,0xb6,0xf3,0xb6,0xed,0xb6,0xef,0xb0,0xa2,0xb6,0xf4,0xb6,0xeb,0xb6,0xf0,0xb6,0xf1,0xb6,0xf2,0xb6,0xf5,0xef,0xb0,0xda,0xcc,0xdb,0xd1,0xef,0xc9,0xe3,0xd5,0xdd,0xe0,0xdc,0xc3,0xe9,0xee,0xe6,0xb9,0xdd,0xad,0xf6,0xf9,0xf2,0xa6,0xeb,0xf1,0xe3,0xb5,0xdf,0xc0,0xd8,0xac,0xf0,0xca,0xe5,0xed,0x00};

//const unsigned char PY_mb_en    []={"恩摁嗯"};
const unsigned char PY_mb_en    []={0xb6,0xf7,0xde,0xf4,0xe0,0xc5,0x00};

//const unsigned char PY_mb_er    []={"而二耳儿饵尔贰洱珥鲕鸸佴迩铒"};
const unsigned char PY_mb_er    []={0xb6,0xf8,0xb6,0xfe,0xb6,0xfa,0xb6,0xf9,0xb6,0xfc,0xb6,0xfb,0xb7,0xa1,0xb6,0xfd,0xe7,0xed,0xf6,0xdc,0xf0,0xb9,0xd9,0xa6,0xe5,0xc7,0xee,0xef,0x00};

//const unsigned char PY_mb_fa    []={"发法罚伐乏筏阀珐垡砝"};
const unsigned char PY_mb_fa    []={0xb7,0xa2,0xb7,0xa8,0xb7,0xa3,0xb7,0xa5,0xb7,0xa6,0xb7,0xa4,0xb7,0xa7,0xb7,0xa9,0xdb,0xd2,0xed,0xc0,0x00};

//const unsigned char PY_mb_fan   []={"反饭翻番犯凡帆返泛繁烦贩范樊藩矾钒燔蘩畈蕃蹯梵幡"};
const unsigned char PY_mb_fan   []={0xb7,0xb4,0xb7,0xb9,0xb7,0xad,0xb7,0xac,0xb7,0xb8,0xb7,0xb2,0xb7,0xab,0xb7,0xb5,0xb7,0xba,0xb7,0xb1,0xb7,0xb3,0xb7,0xb7,0xb7,0xb6,0xb7,0xae,0xb7,0xaa,0xb7,0xaf,0xb7,0xb0,0xec,0xdc,0xde,0xc0,0xee,0xb2,0xde,0xac,0xf5,0xec,0xe8,0xf3,0xe1,0xa6,0x00};

//const unsigned char PY_mb_fang  []={"放房防纺芳方访仿坊妨肪钫彷邡枋舫鲂"};
const unsigned char PY_mb_fang  []={0xb7,0xc5,0xb7,0xbf,0xb7,0xc0,0xb7,0xc4,0xb7,0xbc,0xb7,0xbd,0xb7,0xc3,0xb7,0xc2,0xb7,0xbb,0xb7,0xc1,0xb7,0xbe,0xee,0xd5,0xe1,0xdd,0xda,0xfa,0xe8,0xca,0xf4,0xb3,0xf6,0xd0,0x00};

//const unsigned char PY_mb_fei   []={"非飞肥费肺废匪吠沸菲诽啡篚蜚腓扉妃斐狒芾悱镄霏翡榧淝鲱绯痱"};
const unsigned char PY_mb_fei   []={0xb7,0xc7,0xb7,0xc9,0xb7,0xca,0xb7,0xd1,0xb7,0xce,0xb7,0xcf,0xb7,0xcb,0xb7,0xcd,0xb7,0xd0,0xb7,0xc6,0xb7,0xcc,0xb7,0xc8,0xf3,0xf5,0xf2,0xe3,0xeb,0xe8,0xec,0xe9,0xe5,0xfa,0xec,0xb3,0xe1,0xf4,0xdc,0xc0,0xe3,0xad,0xef,0xd0,0xf6,0xad,0xf4,0xe4,0xe9,0xbc,0xe4,0xc7,0xf6,0xee,0xe7,0xb3,0xf0,0xf2,0x00};

//const unsigned char PY_mb_fen   []={"分份芬粉坟奋愤纷忿粪酚焚吩氛汾棼瀵鲼玢偾鼢"};
const unsigned char PY_mb_fen   []={0xb7,0xd6,0xb7,0xdd,0xb7,0xd2,0xb7,0xdb,0xb7,0xd8,0xb7,0xdc,0xb7,0xdf,0xb7,0xd7,0xb7,0xde,0xb7,0xe0,0xb7,0xd3,0xb7,0xd9,0xb7,0xd4,0xb7,0xd5,0xb7,0xda,0xe8,0xfb,0xe5,0xaf,0xf6,0xf7,0xe7,0xe3,0xd9,0xc7,0xf7,0xf7,0x00};

//const unsigned char PY_mb_feng  []={"风封逢缝蜂丰枫疯冯奉讽凤峰锋烽砜俸酆葑沣唪"};
const unsigned char PY_mb_feng  []={0xb7,0xe7,0xb7,0xe2,0xb7,0xea,0xb7,0xec,0xb7,0xe4,0xb7,0xe1,0xb7,0xe3,0xb7,0xe8,0xb7,0xeb,0xb7,0xee,0xb7,0xed,0xb7,0xef,0xb7,0xe5,0xb7,0xe6,0xb7,0xe9,0xed,0xbf,0xd9,0xba,0xdb,0xba,0xdd,0xd7,0xe3,0xe3,0xdf,0xf4,0x00};

//const unsigned char PY_mb_fo    []={"佛"};
const unsigned char PY_mb_fo    []={0xb7,0xf0,0x00};

//const unsigned char PY_mb_fou   []={"否缶"};
const unsigned char PY_mb_fou   []={0xb7,0xf1,0xf3,0xbe,0x00};

//const unsigned char PY_mb_fu    []={"副幅扶浮富福负伏付复服附俯斧赴缚拂夫父符孵敷赋辅府腐腹妇抚覆辐肤氟佛俘傅讣弗涪袱市甫釜脯腑阜咐黼砩苻趺跗蚨芾鲋幞茯滏蜉拊菔蝠鳆蝮绂绋赙罘稃匐麸凫桴莩孚馥驸怫祓呋郛芙艴"};
const unsigned char PY_mb_fu    []={0xb8,0xb1,0xb7,0xf9,0xb7,0xf6,0xb8,0xa1,0xb8,0xbb,0xb8,0xa3,0xb8,0xba,0xb7,0xfc,0xb8,0xb6,0xb8,0xb4,0xb7,0xfe,0xb8,0xbd,0xb8,0xa9,0xb8,0xab,0xb8,0xb0,0xb8,0xbf,0xb7,0xf7,0xb7,0xf2,0xb8,0xb8,0xb7,0xfb,0xb7,0xf5,0xb7,0xf3,0xb8,0xb3,0xb8,0xa8,0xb8,0xae,0xb8,0xaf,0xb8,0xb9,0xb8,0xbe,0xb8,0xa7,0xb8,0xb2,0xb7,0xf8,0xb7,0xf4,0xb7,0xfa,0xb7,0xf0,0xb7,0xfd,0xb8,0xb5,0xb8,0xbc,0xb8,0xa5,0xb8,0xa2,0xb8,0xa4,0xca,0xd0,0xb8,0xa6,0xb8,0xaa,0xb8,0xac,0xb8,0xad,0xb8,0xb7,0xb8,0xc0,0xed,0xeb,0xed,0xc9,0xdc,0xde,0xf5,0xc3,0xf5,0xc6,0xf2,0xb6,0xdc,0xc0,0xf6,0xd6,0xe1,0xa5,0xdc,0xf2,0xe4,0xe6,0xf2,0xdd,0xde,0xd4,0xdd,0xca,0xf2,0xf0,0xf6,0xfb,0xf2,0xf3,0xe7,0xa6,0xe7,0xa8,0xea,0xe7,0xee,0xb7,0xef,0xfb,0xd9,0xeb,0xf4,0xef,0xd9,0xec,0xe8,0xf5,0xdd,0xb3,0xe6,0xda,0xf0,0xa5,0xe6,0xe2,0xe2,0xf6,0xec,0xf0,0xdf,0xbb,0xdb,0xae,0xdc,0xbd,0xe5,0xf5,0x00};

//const unsigned char PY_mb_ga    []={"噶胳夹嘎咖轧钆伽旮尬尕尜呷"};
const unsigned char PY_mb_ga    []={0xb8,0xc1,0xb8,0xec,0xbc,0xd0,0xb8,0xc2,0xbf,0xa7,0xd4,0xfe,0xee,0xc5,0xd9,0xa4,0xea,0xb8,0xde,0xce,0xe6,0xd8,0xe6,0xd9,0xdf,0xc8,0x00};

//const unsigned char PY_mb_gai   []={"该改盖概钙芥溉戤垓丐陔赅"};
const unsigned char PY_mb_gai   []={0xb8,0xc3,0xb8,0xc4,0xb8,0xc7,0xb8,0xc5,0xb8,0xc6,0xbd,0xe6,0xb8,0xc8,0xea,0xae,0xdb,0xf2,0xd8,0xa4,0xda,0xeb,0xea,0xe0,0x00};

//const unsigned char PY_mb_gan   []={"赶干感敢竿甘肝柑杆赣秆旰酐矸疳泔苷擀绀橄澉淦尴坩"};
const unsigned char PY_mb_gan   []={0xb8,0xcf,0xb8,0xc9,0xb8,0xd0,0xb8,0xd2,0xb8,0xcd,0xb8,0xca,0xb8,0xce,0xb8,0xcc,0xb8,0xcb,0xb8,0xd3,0xb8,0xd1,0xea,0xba,0xf4,0xfb,0xed,0xb7,0xf0,0xe1,0xe3,0xef,0xdc,0xd5,0xdf,0xa6,0xe7,0xa4,0xe9,0xcf,0xe4,0xf7,0xe4,0xc6,0xde,0xcf,0xdb,0xe1,0x00};

//const unsigned char PY_mb_gang  []={"刚钢纲港缸岗杠冈肛扛筻罡戆"};
const unsigned char PY_mb_gang  []={0xb8,0xd5,0xb8,0xd6,0xb8,0xd9,0xb8,0xdb,0xb8,0xd7,0xb8,0xda,0xb8,0xdc,0xb8,0xd4,0xb8,0xd8,0xbf,0xb8,0xf3,0xe0,0xee,0xb8,0xed,0xb0,0x00};

//const unsigned char PY_mb_gao   []={"高搞告稿膏篙羔糕镐皋郜诰杲缟睾槔锆槁藁"};
const unsigned char PY_mb_gao   []={0xb8,0xdf,0xb8,0xe3,0xb8,0xe6,0xb8,0xe5,0xb8,0xe0,0xb8,0xdd,0xb8,0xe1,0xb8,0xe2,0xb8,0xe4,0xb8,0xde,0xdb,0xac,0xda,0xbe,0xea,0xbd,0xe7,0xc9,0xd8,0xba,0xe9,0xc0,0xef,0xaf,0xe9,0xc2,0xde,0xbb,0x00};

//const unsigned char PY_mb_ge    []={"个各歌割哥搁格阁隔革咯胳葛蛤戈鸽疙盖屹合铬硌骼颌袼塥虼圪镉仡舸鬲嗝膈搿纥哿"};
const unsigned char PY_mb_ge    []={0xb8,0xf6,0xb8,0xf7,0xb8,0xe8,0xb8,0xee,0xb8,0xe7,0xb8,0xe9,0xb8,0xf1,0xb8,0xf3,0xb8,0xf4,0xb8,0xef,0xbf,0xa9,0xb8,0xec,0xb8,0xf0,0xb8,0xf2,0xb8,0xea,0xb8,0xeb,0xb8,0xed,0xb8,0xc7,0xd2,0xd9,0xba,0xcf,0xb8,0xf5,0xed,0xd1,0xf7,0xc0,0xf2,0xa2,0xf1,0xcb,0xdc,0xaa,0xf2,0xb4,0xdb,0xd9,0xef,0xd3,0xd8,0xee,0xf4,0xb4,0xd8,0xaa,0xe0,0xc3,0xeb,0xf5,0xeb,0xa1,0xe6,0xfc,0xdb,0xc1,0x00};

//const unsigned char PY_mb_gei   []={"给"};
const unsigned char PY_mb_gei   []={0xb8,0xf8,0x00};

//const unsigned char PY_mb_gen   []={"跟根哏茛亘艮"};
const unsigned char PY_mb_gen   []={0xb8,0xfa,0xb8,0xf9,0xdf,0xe7,0xdd,0xa2,0xd8,0xa8,0xf4,0xde,0x00};

//const unsigned char PY_mb_geng  []={"更耕颈梗耿庚羹埂赓鲠哽绠"};
const unsigned char PY_mb_geng  []={0xb8,0xfc,0xb8,0xfb,0xbe,0xb1,0xb9,0xa3,0xb9,0xa2,0xb8,0xfd,0xb8,0xfe,0xb9,0xa1,0xe2,0xd9,0xf6,0xe1,0xdf,0xec,0xe7,0xae,0x00};

//const unsigned char PY_mb_gong  []={"工公功共弓攻宫供恭拱贡躬巩汞龚红肱觥珙蚣"};
const unsigned char PY_mb_gong  []={0xb9,0xa4,0xb9,0xab,0xb9,0xa6,0xb9,0xb2,0xb9,0xad,0xb9,0xa5,0xb9,0xac,0xb9,0xa9,0xb9,0xa7,0xb9,0xb0,0xb9,0xb1,0xb9,0xaa,0xb9,0xae,0xb9,0xaf,0xb9,0xa8,0xba,0xec,0xeb,0xc5,0xf6,0xa1,0xe7,0xee,0xf2,0xbc,0x00};

//const unsigned char PY_mb_gou   []={"够沟狗钩勾购构苟垢句岣彀枸鞲觏缑笱诟遘媾篝佝"};
const unsigned char PY_mb_gou   []={0xb9,0xbb,0xb9,0xb5,0xb9,0xb7,0xb9,0xb3,0xb9,0xb4,0xb9,0xba,0xb9,0xb9,0xb9,0xb6,0xb9,0xb8,0xbe,0xe4,0xe1,0xb8,0xec,0xb0,0xe8,0xdb,0xf7,0xb8,0xea,0xed,0xe7,0xc3,0xf3,0xd1,0xda,0xb8,0xe5,0xdc,0xe6,0xc5,0xf3,0xf4,0xd8,0xfe,0x00};

//const unsigned char PY_mb_gu    []={"古股鼓谷故孤箍姑顾固雇估咕骨辜沽蛊贾菇梏鸪汩轱崮菰鹄鹘钴臌酤呱鲴诂牯瞽毂锢牿痼觚蛄罟嘏"};
const unsigned char PY_mb_gu    []={0xb9,0xc5,0xb9,0xc9,0xb9,0xc4,0xb9,0xc8,0xb9,0xca,0xb9,0xc2,0xb9,0xbf,0xb9,0xc3,0xb9,0xcb,0xb9,0xcc,0xb9,0xcd,0xb9,0xc0,0xb9,0xbe,0xb9,0xc7,0xb9,0xbc,0xb9,0xc1,0xb9,0xc6,0xbc,0xd6,0xb9,0xbd,0xe8,0xf4,0xf0,0xb3,0xe3,0xe9,0xe9,0xef,0xe1,0xc4,0xdd,0xd4,0xf0,0xc0,0xf7,0xbd,0xee,0xdc,0xeb,0xfb,0xf4,0xfe,0xdf,0xc9,0xf6,0xf1,0xda,0xac,0xea,0xf4,0xee,0xad,0xec,0xb1,0xef,0xc0,0xea,0xf6,0xf0,0xf3,0xf5,0xfd,0xf2,0xc1,0xee,0xb9,0xd8,0xc5,0x00};

//const unsigned char PY_mb_gua   []={"挂刮瓜寡剐褂卦呱胍鸹栝诖"};
const unsigned char PY_mb_gua   []={0xb9,0xd2,0xb9,0xce,0xb9,0xcf,0xb9,0xd1,0xb9,0xd0,0xb9,0xd3,0xd8,0xd4,0xdf,0xc9,0xeb,0xd2,0xf0,0xbb,0xe8,0xe9,0xda,0xb4,0x00};

//const unsigned char PY_mb_guai  []={"怪拐乖掴"};
const unsigned char PY_mb_guai  []={0xb9,0xd6,0xb9,0xd5,0xb9,0xd4,0xde,0xe2,0x00};

//const unsigned char PY_mb_guan  []={"关管官观馆惯罐灌冠贯棺纶盥矜莞掼涫鳏鹳倌"};
const unsigned char PY_mb_guan  []={0xb9,0xd8,0xb9,0xdc,0xb9,0xd9,0xb9,0xdb,0xb9,0xdd,0xb9,0xdf,0xb9,0xde,0xb9,0xe0,0xb9,0xda,0xb9,0xe1,0xb9,0xd7,0xc2,0xda,0xee,0xc2,0xf1,0xe6,0xdd,0xb8,0xde,0xe8,0xe4,0xca,0xf7,0xa4,0xf0,0xd9,0xd9,0xc4,0x00};

//const unsigned char PY_mb_guang []={"光广逛桄犷咣胱"};
const unsigned char PY_mb_guang []={0xb9,0xe2,0xb9,0xe3,0xb9,0xe4,0xe8,0xe6,0xe1,0xee,0xdf,0xdb,0xeb,0xd7,0x00};

//const unsigned char PY_mb_gui   []={"归贵鬼跪轨规硅桂柜龟诡闺瑰圭刽傀癸炔庋宄桧刿鳜鲑皈匦妫晷簋炅"};
const unsigned char PY_mb_gui   []={0xb9,0xe9,0xb9,0xf3,0xb9,0xed,0xb9,0xf2,0xb9,0xec,0xb9,0xe6,0xb9,0xe8,0xb9,0xf0,0xb9,0xf1,0xb9,0xea,0xb9,0xee,0xb9,0xeb,0xb9,0xe5,0xb9,0xe7,0xb9,0xf4,0xbf,0xfe,0xb9,0xef,0xc8,0xb2,0xe2,0xd1,0xe5,0xb3,0xe8,0xed,0xd8,0xdb,0xf7,0xac,0xf6,0xd9,0xf0,0xa7,0xd8,0xd0,0xe6,0xa3,0xea,0xd0,0xf3,0xfe,0xea,0xc1,0x00};

//const unsigned char PY_mb_gun   []={"滚棍辊鲧衮磙绲"};
const unsigned char PY_mb_gun   []={0xb9,0xf6,0xb9,0xf7,0xb9,0xf5,0xf6,0xe7,0xd9,0xf2,0xed,0xde,0xe7,0xb5,0x00};

//const unsigned char PY_mb_guo   []={"过国果裹锅郭涡埚椁聒馘猓崞掴帼呙虢蜾蝈"};
const unsigned char PY_mb_guo   []={0xb9,0xfd,0xb9,0xfa,0xb9,0xfb,0xb9,0xfc,0xb9,0xf8,0xb9,0xf9,0xce,0xd0,0xdb,0xf6,0xe9,0xa4,0xf1,0xf8,0xd9,0xe5,0xe2,0xa3,0xe1,0xc6,0xde,0xe2,0xe0,0xfe,0xdf,0xc3,0xeb,0xbd,0xf2,0xe4,0xf2,0xe5,0x00};

//const unsigned char PY_mb_ha    []={"哈蛤虾铪"};
const unsigned char PY_mb_ha    []={0xb9,0xfe,0xb8,0xf2,0xcf,0xba,0xee,0xfe,0x00};

//const unsigned char PY_mb_hai   []={"还海害咳氦孩骇骸亥嗨醢胲"};
const unsigned char PY_mb_hai   []={0xbb,0xb9,0xba,0xa3,0xba,0xa6,0xbf,0xc8,0xba,0xa4,0xba,0xa2,0xba,0xa7,0xba,0xa1,0xba,0xa5,0xe0,0xcb,0xf5,0xb0,0xeb,0xdc,0x00};

//const unsigned char PY_mb_han   []={"喊含汗寒汉旱酣韩焊涵函憨翰罕撼捍憾悍邯邗菡撖瀚阚顸蚶焓颔晗鼾"};
const unsigned char PY_mb_han   []={0xba,0xb0,0xba,0xac,0xba,0xb9,0xba,0xae,0xba,0xba,0xba,0xb5,0xba,0xa8,0xba,0xab,0xba,0xb8,0xba,0xad,0xba,0xaf,0xba,0xa9,0xba,0xb2,0xba,0xb1,0xba,0xb3,0xba,0xb4,0xba,0xb6,0xba,0xb7,0xba,0xaa,0xda,0xf5,0xdd,0xd5,0xde,0xfe,0xe5,0xab,0xe3,0xdb,0xf1,0xfc,0xf2,0xc0,0xec,0xca,0xf2,0xa5,0xea,0xcf,0xf7,0xfd,0x00};

//const unsigned char PY_mb_hang  []={"行巷航夯杭吭颃沆绗珩"};
const unsigned char PY_mb_hang  []={0xd0,0xd0,0xcf,0xef,0xba,0xbd,0xba,0xbb,0xba,0xbc,0xbf,0xd4,0xf1,0xfe,0xe3,0xec,0xe7,0xac,0xe7,0xf1,0x00};

//const unsigned char PY_mb_hao   []={"好号浩嚎壕郝毫豪耗貉镐昊颢灏嚆蚝嗥皓蒿濠薅"};
const unsigned char PY_mb_hao   []={0xba,0xc3,0xba,0xc5,0xba,0xc6,0xba,0xbf,0xba,0xbe,0xba,0xc2,0xba,0xc1,0xba,0xc0,0xba,0xc4,0xba,0xd1,0xb8,0xe4,0xea,0xbb,0xf2,0xab,0xe5,0xb0,0xe0,0xe3,0xf2,0xba,0xe0,0xc6,0xf0,0xa9,0xdd,0xef,0xe5,0xa9,0xde,0xb6,0x00};

//const unsigned char PY_mb_he    []={"和喝合河禾核何呵荷贺赫褐盒鹤菏貉阂涸吓嗬劾盍翮阖颌壑诃纥曷"};
const unsigned char PY_mb_he    []={0xba,0xcd,0xba,0xc8,0xba,0xcf,0xba,0xd3,0xba,0xcc,0xba,0xcb,0xba,0xce,0xba,0xc7,0xba,0xc9,0xba,0xd8,0xba,0xd5,0xba,0xd6,0xba,0xd0,0xba,0xd7,0xba,0xca,0xba,0xd1,0xba,0xd2,0xba,0xd4,0xcf,0xc5,0xe0,0xc0,0xdb,0xc0,0xee,0xc1,0xf4,0xe7,0xe3,0xd8,0xf2,0xa2,0xdb,0xd6,0xda,0xad,0xe6,0xfc,0xea,0xc2,0x00};

//const unsigned char PY_mb_hei   []={"黑嘿"};
const unsigned char PY_mb_hei   []={0xba,0xda,0xba,0xd9,0x00};

//const unsigned char PY_mb_hen   []={"很狠恨痕"};
const unsigned char PY_mb_hen   []={0xba,0xdc,0xba,0xdd,0xba,0xde,0xba,0xdb,0x00};

//const unsigned char PY_mb_heng  []={"横恒哼衡亨行桁珩蘅"};
const unsigned char PY_mb_heng  []={0xba,0xe1,0xba,0xe3,0xba,0xdf,0xba,0xe2,0xba,0xe0,0xd0,0xd0,0xe8,0xec,0xe7,0xf1,0xde,0xbf,0x00};

//const unsigned char PY_mb_hong  []={"红轰哄虹洪宏烘鸿弘讧訇蕻闳薨黉荭泓"};
const unsigned char PY_mb_hong  []={0xba,0xec,0xba,0xe4,0xba,0xe5,0xba,0xe7,0xba,0xe9,0xba,0xea,0xba,0xe6,0xba,0xe8,0xba,0xeb,0xda,0xa7,0xd9,0xea,0xde,0xae,0xe3,0xc8,0xde,0xb0,0xd9,0xe4,0xdd,0xa6,0xe3,0xfc,0x00};

//const unsigned char PY_mb_hou   []={"后厚吼喉侯候猴鲎篌堠後逅糇骺瘊"};
const unsigned char PY_mb_hou   []={0xba,0xf3,0xba,0xf1,0xba,0xf0,0xba,0xed,0xba,0xee,0xba,0xf2,0xba,0xef,0xf6,0xd7,0xf3,0xf3,0xdc,0xa9,0xe1,0xe1,0xe5,0xcb,0xf4,0xd7,0xf7,0xbf,0xf0,0xfa,0x00};

//const unsigned char PY_mb_hu    []={"湖户呼虎壶互胡护糊弧忽狐蝴葫沪乎戏核和瑚唬鹕冱怙鹱笏戽扈鹘浒祜醐琥囫烀轷瓠煳斛鹄猢惚岵滹觳唿槲"};
const unsigned char PY_mb_hu    []={0xba,0xfe,0xbb,0xa7,0xba,0xf4,0xbb,0xa2,0xba,0xf8,0xbb,0xa5,0xba,0xfa,0xbb,0xa4,0xba,0xfd,0xbb,0xa1,0xba,0xf6,0xba,0xfc,0xba,0xfb,0xba,0xf9,0xbb,0xa6,0xba,0xf5,0xcf,0xb7,0xba,0xcb,0xba,0xcd,0xba,0xf7,0xbb,0xa3,0xf0,0xc9,0xd9,0xfc,0xe2,0xef,0xf0,0xd7,0xf3,0xcb,0xec,0xe6,0xec,0xe8,0xf7,0xbd,0xe4,0xb0,0xec,0xef,0xf5,0xad,0xe7,0xfa,0xe0,0xf1,0xec,0xc3,0xe9,0xf5,0xf0,0xad,0xec,0xce,0xf5,0xfa,0xf0,0xc0,0xe2,0xa9,0xe3,0xb1,0xe1,0xb2,0xe4,0xef,0xec,0xb2,0xdf,0xfc,0xe9,0xce,0x00};

//const unsigned char PY_mb_hua   []={"话花化画华划滑哗猾豁铧桦骅砉"};
const unsigned char PY_mb_hua   []={0xbb,0xb0,0xbb,0xa8,0xbb,0xaf,0xbb,0xad,0xbb,0xaa,0xbb,0xae,0xbb,0xac,0xbb,0xa9,0xbb,0xab,0xbb,0xed,0xee,0xfc,0xe8,0xeb,0xe6,0xe8,0xed,0xb9,0x00};

//const unsigned char PY_mb_huai  []={"坏怀淮槐徊划踝"};
const unsigned char PY_mb_huai  []={0xbb,0xb5,0xbb,0xb3,0xbb,0xb4,0xbb,0xb1,0xbb,0xb2,0xbb,0xae,0xf5,0xd7,0x00};

//const unsigned char PY_mb_huan  []={"换还唤环患缓欢幻宦涣焕豢桓痪漶獾擐逭鲩郇鬟寰奂锾圜洹萑缳浣"};
const unsigned char PY_mb_huan  []={0xbb,0xbb,0xbb,0xb9,0xbb,0xbd,0xbb,0xb7,0xbb,0xbc,0xbb,0xba,0xbb,0xb6,0xbb,0xc3,0xbb,0xc2,0xbb,0xc1,0xbb,0xc0,0xbb,0xbf,0xbb,0xb8,0xbb,0xbe,0xe4,0xf1,0xe2,0xb5,0xdf,0xa7,0xe5,0xd5,0xf6,0xe9,0xdb,0xa8,0xf7,0xdf,0xe5,0xbe,0xdb,0xbc,0xef,0xcc,0xe0,0xf7,0xe4,0xa1,0xdd,0xc8,0xe7,0xd9,0xe4,0xbd,0x00};

//const unsigned char PY_mb_huang []={"黄慌晃荒簧凰皇谎惶蝗磺恍煌幌隍肓潢篁徨鳇"};
const unsigned char PY_mb_huang []={0xbb,0xc6,0xbb,0xc5,0xbb,0xce,0xbb,0xc4,0xbb,0xc9,0xbb,0xcb,0xbb,0xca,0xbb,0xd1,0xbb,0xcc,0xbb,0xc8,0xbb,0xc7,0xbb,0xd0,0xbb,0xcd,0xbb,0xcf,0xda,0xf2,0xeb,0xc1,0xe4,0xea,0xf3,0xf2,0xe1,0xe5,0xf6,0xfc,0x00};

//const unsigned char PY_mb_hui   []={"回会灰绘挥汇辉毁悔惠晦徽恢秽慧贿蛔讳徊卉烩诲彗浍珲蕙喙恚哕晖隳麾诙蟪茴洄咴虺荟缋"};
const unsigned char PY_mb_hui   []={0xbb,0xd8,0xbb,0xe1,0xbb,0xd2,0xbb,0xe6,0xbb,0xd3,0xbb,0xe3,0xbb,0xd4,0xbb,0xd9,0xbb,0xda,0xbb,0xdd,0xbb,0xde,0xbb,0xd5,0xbb,0xd6,0xbb,0xe0,0xbb,0xdb,0xbb,0xdf,0xbb,0xd7,0xbb,0xe4,0xbb,0xb2,0xbb,0xdc,0xbb,0xe2,0xbb,0xe5,0xe5,0xe7,0xe4,0xab,0xe7,0xf5,0xde,0xa5,0xe0,0xb9,0xed,0xa3,0xdf,0xdc,0xea,0xcd,0xe3,0xc4,0xf7,0xe2,0xda,0xb6,0xf3,0xb3,0xdc,0xee,0xe4,0xa7,0xdf,0xd4,0xf2,0xb3,0xdc,0xf6,0xe7,0xc0,0x00};

//const unsigned char PY_mb_hun   []={"混昏荤浑婚魂阍珲馄溷诨"};
const unsigned char PY_mb_hun   []={0xbb,0xec,0xbb,0xe8,0xbb,0xe7,0xbb,0xeb,0xbb,0xe9,0xbb,0xea,0xe3,0xd4,0xe7,0xf5,0xe2,0xc6,0xe4,0xe3,0xda,0xbb,0x00};

//const unsigned char PY_mb_huo   []={"或活火伙货和获祸豁霍惑嚯镬耠劐藿攉锪蠖钬夥"};
const unsigned char PY_mb_huo   []={0xbb,0xf2,0xbb,0xee,0xbb,0xf0,0xbb,0xef,0xbb,0xf5,0xba,0xcd,0xbb,0xf1,0xbb,0xf6,0xbb,0xed,0xbb,0xf4,0xbb,0xf3,0xe0,0xeb,0xef,0xec,0xf1,0xeb,0xd8,0xe5,0xde,0xbd,0xdf,0xab,0xef,0xc1,0xf3,0xb6,0xee,0xd8,0xe2,0xb7,0x00};

//const unsigned char PY_mb_ji    []={"几及急既即机鸡积记级极计挤己季寄纪系基激吉脊际击圾畸箕肌饥迹讥姬绩棘辑籍缉集疾汲嫉蓟技冀伎祭剂悸济寂期其奇忌齐妓继给革稽墼洎鲚屐齑戟鲫嵇矶稷戢虮诘笈暨笄剞叽蒺跻嵴掎跽霁唧畿荠瘠玑羁丌偈芨佶赍楫髻咭蕺觊麂"};
const unsigned char PY_mb_ji    []={0xbc,0xb8,0xbc,0xb0,0xbc,0xb1,0xbc,0xc8,0xbc,0xb4,0xbb,0xfa,0xbc,0xa6,0xbb,0xfd,0xbc,0xc7,0xbc,0xb6,0xbc,0xab,0xbc,0xc6,0xbc,0xb7,0xbc,0xba,0xbc,0xbe,0xbc,0xc4,0xbc,0xcd,0xcf,0xb5,0xbb,0xf9,0xbc,0xa4,0xbc,0xaa,0xbc,0xb9,0xbc,0xca,0xbb,0xf7,0xbb,0xf8,0xbb,0xfb,0xbb,0xfe,0xbc,0xa1,0xbc,0xa2,0xbc,0xa3,0xbc,0xa5,0xbc,0xa7,0xbc,0xa8,0xbc,0xac,0xbc,0xad,0xbc,0xae,0xbc,0xa9,0xbc,0xaf,0xbc,0xb2,0xbc,0xb3,0xbc,0xb5,0xbc,0xbb,0xbc,0xbc,0xbc,0xbd,0xbc,0xbf,0xbc,0xc0,0xbc,0xc1,0xbc,0xc2,0xbc,0xc3,0xbc,0xc5,0xc6,0xda,0xc6,0xe4,0xc6,0xe6,0xbc,0xc9,0xc6,0xeb,0xbc,0xcb,0xbc,0xcc,0xb8,0xf8,0xb8,0xef,0xbb,0xfc,0xdb,0xd4,0xe4,0xa9,0xf6,0xdd,0xe5,0xec,0xec,0xb4,0xea,0xaa,0xf6,0xea,0xef,0xfa,0xed,0xb6,0xf0,0xa2,0xea,0xab,0xf2,0xb1,0xda,0xb5,0xf3,0xc5,0xf4,0xdf,0xf3,0xc7,0xd8,0xde,0xdf,0xb4,0xdd,0xf0,0xf5,0xd2,0xe1,0xd5,0xde,0xe1,0xf5,0xd5,0xf6,0xab,0xdf,0xf3,0xe7,0xdc,0xdc,0xf9,0xf1,0xa4,0xe7,0xe1,0xee,0xbf,0xd8,0xa2,0xd9,0xca,0xdc,0xb8,0xd9,0xa5,0xea,0xe5,0xe9,0xae,0xf7,0xd9,0xdf,0xd2,0xde,0xaa,0xea,0xe9,0xf7,0xe4,0x00};

//const unsigned char PY_mb_jia   []={"家加假价架甲佳夹嘉驾嫁枷荚颊钾稼茄贾铗葭迦戛浃镓痂恝岬跏嘏伽胛笳珈瘕郏袈蛱"};
const unsigned char PY_mb_jia   []={0xbc,0xd2,0xbc,0xd3,0xbc,0xd9,0xbc,0xdb,0xbc,0xdc,0xbc,0xd7,0xbc,0xd1,0xbc,0xd0,0xbc,0xce,0xbc,0xdd,0xbc,0xde,0xbc,0xcf,0xbc,0xd4,0xbc,0xd5,0xbc,0xd8,0xbc,0xda,0xc7,0xd1,0xbc,0xd6,0xee,0xf2,0xdd,0xe7,0xe5,0xc8,0xea,0xa9,0xe4,0xa4,0xef,0xd8,0xf0,0xe8,0xed,0xa2,0xe1,0xb5,0xf5,0xca,0xd8,0xc5,0xd9,0xa4,0xeb,0xce,0xf3,0xd5,0xe7,0xec,0xf0,0xfd,0xdb,0xa3,0xf4,0xc2,0xf2,0xcc,0x00};

//const unsigned char PY_mb_jian  []={"见件减尖间键贱肩兼建检箭煎简剪歼监坚奸健艰荐剑渐溅涧鉴浅践捡柬笺俭碱硷拣舰槛缄茧饯翦鞯戋谏牮枧腱趼缣搛戬毽菅鲣笕谫楗囝蹇裥踺睑謇鹣蒹僭锏湔"};
const unsigned char PY_mb_jian  []={0xbc,0xfb,0xbc,0xfe,0xbc,0xf5,0xbc,0xe2,0xbc,0xe4,0xbc,0xfc,0xbc,0xfa,0xbc,0xe7,0xbc,0xe6,0xbd,0xa8,0xbc,0xec,0xbc,0xfd,0xbc,0xe5,0xbc,0xf2,0xbc,0xf4,0xbc,0xdf,0xbc,0xe0,0xbc,0xe1,0xbc,0xe9,0xbd,0xa1,0xbc,0xe8,0xbc,0xf6,0xbd,0xa3,0xbd,0xa5,0xbd,0xa6,0xbd,0xa7,0xbc,0xf8,0xc7,0xb3,0xbc,0xf9,0xbc,0xf1,0xbc,0xed,0xbc,0xe3,0xbc,0xf3,0xbc,0xee,0xbc,0xef,0xbc,0xf0,0xbd,0xa2,0xbc,0xf7,0xbc,0xea,0xbc,0xeb,0xbd,0xa4,0xf4,0xe5,0xf7,0xb5,0xea,0xa7,0xda,0xc9,0xea,0xf0,0xe8,0xc5,0xeb,0xec,0xf5,0xc2,0xe7,0xcc,0xde,0xf6,0xea,0xaf,0xeb,0xa6,0xdd,0xd1,0xf6,0xe4,0xf3,0xc8,0xda,0xd9,0xe9,0xa5,0xe0,0xee,0xe5,0xbf,0xf1,0xd0,0xf5,0xdd,0xed,0xfa,0xe5,0xc0,0xf0,0xcf,0xdd,0xf3,0xd9,0xd4,0xef,0xb5,0xe4,0xd5,0x00};

//const unsigned char PY_mb_jiang []={"将讲江奖降浆僵姜酱蒋疆匠强桨虹豇礓缰犟耩绛茳糨洚"};
const unsigned char PY_mb_jiang []={0xbd,0xab,0xbd,0xb2,0xbd,0xad,0xbd,0xb1,0xbd,0xb5,0xbd,0xac,0xbd,0xa9,0xbd,0xaa,0xbd,0xb4,0xbd,0xaf,0xbd,0xae,0xbd,0xb3,0xc7,0xbf,0xbd,0xb0,0xba,0xe7,0xf4,0xf8,0xed,0xe4,0xe7,0xd6,0xea,0xf1,0xf1,0xf0,0xe7,0xad,0xdc,0xfc,0xf4,0xdd,0xe4,0xae,0x00};

//const unsigned char PY_mb_jiao  []={"叫脚交角教较缴觉焦胶娇绞校搅骄狡浇矫郊嚼蕉轿窖椒礁饺铰酵侥剿徼艽僬蛟敫峤跤姣皎茭鹪噍醮佼湫鲛挢"};
const unsigned char PY_mb_jiao  []={0xbd,0xd0,0xbd,0xc5,0xbd,0xbb,0xbd,0xc7,0xbd,0xcc,0xbd,0xcf,0xbd,0xc9,0xbe,0xf5,0xbd,0xb9,0xbd,0xba,0xbd,0xbf,0xbd,0xca,0xd0,0xa3,0xbd,0xc1,0xbd,0xbe,0xbd,0xc6,0xbd,0xbd,0xbd,0xc3,0xbd,0xbc,0xbd,0xc0,0xbd,0xb6,0xbd,0xce,0xbd,0xd1,0xbd,0xb7,0xbd,0xb8,0xbd,0xc8,0xbd,0xc2,0xbd,0xcd,0xbd,0xc4,0xbd,0xcb,0xe1,0xe8,0xdc,0xb4,0xd9,0xd5,0xf2,0xd4,0xeb,0xb8,0xe1,0xbd,0xf5,0xd3,0xe6,0xaf,0xf0,0xa8,0xdc,0xfa,0xf0,0xd4,0xe0,0xdd,0xf5,0xb4,0xd9,0xae,0xe4,0xd0,0xf6,0xde,0xde,0xd8,0x00};

//const unsigned char PY_mb_jie   []={"接节街借皆截解界结届姐揭戒介阶劫芥竭洁疥藉价楷秸桔杰捷诫睫家偈桀喈拮骱羯蚧嗟颉鲒婕碣讦孑疖诘"};
const unsigned char PY_mb_jie   []={0xbd,0xd3,0xbd,0xda,0xbd,0xd6,0xbd,0xe8,0xbd,0xd4,0xbd,0xd8,0xbd,0xe2,0xbd,0xe7,0xbd,0xe1,0xbd,0xec,0xbd,0xe3,0xbd,0xd2,0xbd,0xe4,0xbd,0xe9,0xbd,0xd7,0xbd,0xd9,0xbd,0xe6,0xbd,0xdf,0xbd,0xe0,0xbd,0xea,0xbd,0xe5,0xbc,0xdb,0xbf,0xac,0xbd,0xd5,0xbd,0xdb,0xbd,0xdc,0xbd,0xdd,0xbd,0xeb,0xbd,0xde,0xbc,0xd2,0xd9,0xca,0xe8,0xee,0xe0,0xae,0xde,0xd7,0xf7,0xba,0xf4,0xc9,0xf2,0xbb,0xe0,0xb5,0xf2,0xa1,0xf6,0xda,0xe6,0xbc,0xed,0xd9,0xda,0xa6,0xe6,0xdd,0xf0,0xdc,0xda,0xb5,0x00};

//const unsigned char PY_mb_jin   []={"进近今仅紧金斤尽劲禁浸锦晋筋津谨巾襟烬靳廑瑾馑槿衿堇荩矜噤缙卺妗赆觐"};
const unsigned char PY_mb_jin   []={0xbd,0xf8,0xbd,0xfc,0xbd,0xf1,0xbd,0xf6,0xbd,0xf4,0xbd,0xf0,0xbd,0xef,0xbe,0xa1,0xbe,0xa2,0xbd,0xfb,0xbd,0xfe,0xbd,0xf5,0xbd,0xfa,0xbd,0xee,0xbd,0xf2,0xbd,0xf7,0xbd,0xed,0xbd,0xf3,0xbd,0xfd,0xbd,0xf9,0xe2,0xdb,0xe8,0xaa,0xe2,0xcb,0xe9,0xc8,0xf1,0xc6,0xdd,0xc0,0xdd,0xa3,0xf1,0xe6,0xe0,0xe4,0xe7,0xc6,0xda,0xe1,0xe6,0xa1,0xea,0xe1,0xea,0xee,0x00};

//const unsigned char PY_mb_jing  []={"竟静井惊经镜京净敬精景警竞境径荆晶鲸粳颈兢茎睛劲痉靖肼獍阱腈弪刭憬婧胫菁儆旌迳靓泾"};
const unsigned char PY_mb_jing  []={0xbe,0xb9,0xbe,0xb2,0xbe,0xae,0xbe,0xaa,0xbe,0xad,0xbe,0xb5,0xbe,0xa9,0xbe,0xbb,0xbe,0xb4,0xbe,0xab,0xbe,0xb0,0xbe,0xaf,0xbe,0xba,0xbe,0xb3,0xbe,0xb6,0xbe,0xa3,0xbe,0xa7,0xbe,0xa8,0xbe,0xac,0xbe,0xb1,0xbe,0xa4,0xbe,0xa5,0xbe,0xa6,0xbe,0xa2,0xbe,0xb7,0xbe,0xb8,0xeb,0xc2,0xe2,0xb0,0xda,0xe5,0xeb,0xe6,0xe5,0xf2,0xd8,0xd9,0xe3,0xbd,0xe6,0xba,0xeb,0xd6,0xdd,0xbc,0xd9,0xd3,0xec,0xba,0xe5,0xc9,0xf6,0xa6,0xe3,0xfe,0x00};

//const unsigned char PY_mb_jiong []={"窘炯扃迥"};
const unsigned char PY_mb_jiong []={0xbe,0xbd,0xbe,0xbc,0xec,0xe7,0xe5,0xc4,0x00};

//const unsigned char PY_mb_jiu   []={"就九酒旧久揪救纠舅究韭厩臼玖灸咎疚赳鹫蹴僦柩桕鬏鸠阄啾"};
const unsigned char PY_mb_jiu   []={0xbe,0xcd,0xbe,0xc5,0xbe,0xc6,0xbe,0xc9,0xbe,0xc3,0xbe,0xbe,0xbe,0xc8,0xbe,0xc0,0xbe,0xcb,0xbe,0xbf,0xbe,0xc2,0xbe,0xc7,0xbe,0xca,0xbe,0xc1,0xbe,0xc4,0xbe,0xcc,0xbe,0xce,0xf4,0xf1,0xf0,0xd5,0xf5,0xed,0xd9,0xd6,0xe8,0xd1,0xe8,0xea,0xf7,0xdd,0xf0,0xaf,0xe3,0xce,0xe0,0xb1,0x00};

//const unsigned char PY_mb_ju    []={"句举巨局具距锯剧居聚拘菊矩沮拒惧鞠狙驹且据柜桔俱车咀疽踞炬倨醵裾屦犋苴窭飓锔椐苣琚掬榘龃趄莒雎遽橘踽榉鞫钜讵枸"};
const unsigned char PY_mb_ju    []={0xbe,0xe4,0xbe,0xd9,0xbe,0xde,0xbe,0xd6,0xbe,0xdf,0xbe,0xe0,0xbe,0xe2,0xbe,0xe7,0xbe,0xd3,0xbe,0xdb,0xbe,0xd0,0xbe,0xd5,0xbe,0xd8,0xbe,0xda,0xbe,0xdc,0xbe,0xe5,0xbe,0xcf,0xbe,0xd1,0xbe,0xd4,0xc7,0xd2,0xbe,0xdd,0xb9,0xf1,0xbd,0xdb,0xbe,0xe3,0xb3,0xb5,0xbe,0xd7,0xbe,0xd2,0xbe,0xe1,0xbe,0xe6,0xd9,0xc6,0xf5,0xb6,0xf1,0xd5,0xe5,0xf0,0xea,0xf8,0xdc,0xda,0xf1,0xc0,0xec,0xab,0xef,0xb8,0xe9,0xa7,0xdc,0xc4,0xe8,0xa2,0xde,0xe4,0xe9,0xb0,0xf6,0xb4,0xf4,0xf2,0xdc,0xec,0xf6,0xc2,0xe5,0xe1,0xe9,0xd9,0xf5,0xe1,0xe9,0xb7,0xf7,0xb6,0xee,0xd2,0xda,0xaa,0xe8,0xdb,0x00};

//const unsigned char PY_mb_juan  []={"卷圈倦鹃捐娟眷绢鄄锩蠲镌狷桊涓隽"};
const unsigned char PY_mb_juan  []={0xbe,0xed,0xc8,0xa6,0xbe,0xeb,0xbe,0xe9,0xbe,0xe8,0xbe,0xea,0xbe,0xec,0xbe,0xee,0xdb,0xb2,0xef,0xc3,0xee,0xc3,0xef,0xd4,0xe1,0xfa,0xe8,0xf0,0xe4,0xb8,0xf6,0xc1,0x00};

//const unsigned char PY_mb_jue   []={"决绝觉角爵掘诀撅倔抉攫嚼脚桷噱橛嗟觖劂爝矍镢獗珏崛蕨噘谲蹶孓厥"};
const unsigned char PY_mb_jue   []={0xbe,0xf6,0xbe,0xf8,0xbe,0xf5,0xbd,0xc7,0xbe,0xf4,0xbe,0xf2,0xbe,0xf7,0xbe,0xef,0xbe,0xf3,0xbe,0xf1,0xbe,0xf0,0xbd,0xc0,0xbd,0xc5,0xe8,0xf6,0xe0,0xe5,0xe9,0xd3,0xe0,0xb5,0xf5,0xfb,0xd8,0xe3,0xec,0xdf,0xdb,0xc7,0xef,0xe3,0xe2,0xb1,0xe7,0xe5,0xe1,0xc8,0xde,0xa7,0xe0,0xd9,0xda,0xdc,0xf5,0xea,0xe6,0xde,0xd8,0xca,0x00};

//const unsigned char PY_mb_jun   []={"军君均菌俊峻龟竣骏钧浚郡筠麇皲捃"};
const unsigned char PY_mb_jun   []={0xbe,0xfc,0xbe,0xfd,0xbe,0xf9,0xbe,0xfa,0xbf,0xa1,0xbe,0xfe,0xb9,0xea,0xbf,0xa2,0xbf,0xa5,0xbe,0xfb,0xbf,0xa3,0xbf,0xa4,0xf3,0xde,0xf7,0xe5,0xf1,0xe4,0xde,0xdc,0x00};

//const unsigned char PY_mb_ka    []={"卡喀咯咖胩咔佧"};
const unsigned char PY_mb_ka    []={0xbf,0xa8,0xbf,0xa6,0xbf,0xa9,0xbf,0xa7,0xeb,0xcc,0xdf,0xc7,0xd8,0xfb,0x00};

//const unsigned char PY_mb_kai   []={"开揩凯慨楷垲剀锎铠锴忾恺蒈"};
const unsigned char PY_mb_kai   []={0xbf,0xaa,0xbf,0xab,0xbf,0xad,0xbf,0xae,0xbf,0xac,0xdb,0xee,0xd8,0xdc,0xef,0xb4,0xee,0xf8,0xef,0xc7,0xe2,0xe9,0xe2,0xfd,0xdd,0xdc,0x00};

//const unsigned char PY_mb_kan   []={"看砍堪刊嵌坎槛勘龛戡侃瞰莰阚"};
const unsigned char PY_mb_kan   []={0xbf,0xb4,0xbf,0xb3,0xbf,0xb0,0xbf,0xaf,0xc7,0xb6,0xbf,0xb2,0xbc,0xf7,0xbf,0xb1,0xed,0xe8,0xea,0xac,0xd9,0xa9,0xee,0xab,0xdd,0xa8,0xe3,0xdb,0x00};

//const unsigned char PY_mb_kang  []={"抗炕扛糠康慷亢钪闶伉"};
const unsigned char PY_mb_kang  []={0xbf,0xb9,0xbf,0xbb,0xbf,0xb8,0xbf,0xb7,0xbf,0xb5,0xbf,0xb6,0xbf,0xba,0xee,0xd6,0xe3,0xca,0xd8,0xf8,0x00};

//const unsigned char PY_mb_kao   []={"靠考烤拷栲犒尻铐"};
const unsigned char PY_mb_kao   []={0xbf,0xbf,0xbf,0xbc,0xbf,0xbe,0xbf,0xbd,0xe8,0xe0,0xea,0xfb,0xe5,0xea,0xee,0xed,0x00};

//const unsigned char PY_mb_ke    []={"咳可克棵科颗刻课客壳渴苛柯磕坷呵恪岢蝌缂蚵轲窠钶氪颏瞌锞稞珂髁疴嗑溘骒"};
const unsigned char PY_mb_ke    []={0xbf,0xc8,0xbf,0xc9,0xbf,0xcb,0xbf,0xc3,0xbf,0xc6,0xbf,0xc5,0xbf,0xcc,0xbf,0xce,0xbf,0xcd,0xbf,0xc7,0xbf,0xca,0xbf,0xc1,0xbf,0xc2,0xbf,0xc4,0xbf,0xc0,0xba,0xc7,0xe3,0xa1,0xe1,0xb3,0xf2,0xf2,0xe7,0xbc,0xf2,0xc2,0xe9,0xf0,0xf1,0xbd,0xee,0xdd,0xeb,0xb4,0xf2,0xa4,0xee,0xa7,0xef,0xbe,0xef,0xfd,0xe7,0xe6,0xf7,0xc1,0xf0,0xe2,0xe0,0xbe,0xe4,0xdb,0xe6,0xec,0x00};

//const unsigned char PY_mb_ken   []={"肯啃恳垦裉"};
const unsigned char PY_mb_ken   []={0xbf,0xcf,0xbf,0xd0,0xbf,0xd2,0xbf,0xd1,0xf1,0xcc,0x00};

//const unsigned char PY_mb_keng  []={"坑吭铿"};
const unsigned char PY_mb_keng  []={0xbf,0xd3,0xbf,0xd4,0xef,0xac,0x00};

//const unsigned char PY_mb_kong  []={"空孔控恐倥崆箜"};
const unsigned char PY_mb_kong  []={0xbf,0xd5,0xbf,0xd7,0xbf,0xd8,0xbf,0xd6,0xd9,0xc5,0xe1,0xc7,0xf3,0xed,0x00};

//const unsigned char PY_mb_kou   []={"口扣抠寇蔻芤眍筘叩"};
const unsigned char PY_mb_kou   []={0xbf,0xda,0xbf,0xdb,0xbf,0xd9,0xbf,0xdc,0xde,0xa2,0xdc,0xd2,0xed,0xee,0xf3,0xd8,0xdf,0xb5,0x00};

//const unsigned char PY_mb_ku    []={"哭库苦枯裤窟酷刳骷喾堀绔"};
const unsigned char PY_mb_ku    []={0xbf,0xde,0xbf,0xe2,0xbf,0xe0,0xbf,0xdd,0xbf,0xe3,0xbf,0xdf,0xbf,0xe1,0xd8,0xda,0xf7,0xbc,0xe0,0xb7,0xdc,0xa5,0xe7,0xab,0x00};

//const unsigned char PY_mb_kua   []={"跨垮挎夸胯侉"};
const unsigned char PY_mb_kua   []={0xbf,0xe7,0xbf,0xe5,0xbf,0xe6,0xbf,0xe4,0xbf,0xe8,0xd9,0xa8,0x00};

//const unsigned char PY_mb_kuai  []={"快块筷会侩哙蒯浍郐狯脍"};
const unsigned char PY_mb_kuai  []={0xbf,0xec,0xbf,0xe9,0xbf,0xea,0xbb,0xe1,0xbf,0xeb,0xdf,0xe0,0xd8,0xe1,0xe4,0xab,0xdb,0xa6,0xe1,0xf6,0xeb,0xda,0x00};

//const unsigned char PY_mb_kuan  []={"宽款髋"};
const unsigned char PY_mb_kuan  []={0xbf,0xed,0xbf,0xee,0xf7,0xc5,0x00};

//const unsigned char PY_mb_kuang []={"矿筐狂框况旷匡眶诳邝纩夼诓圹贶哐"};
const unsigned char PY_mb_kuang []={0xbf,0xf3,0xbf,0xf0,0xbf,0xf1,0xbf,0xf2,0xbf,0xf6,0xbf,0xf5,0xbf,0xef,0xbf,0xf4,0xda,0xbf,0xda,0xf7,0xe6,0xfe,0xde,0xc5,0xda,0xb2,0xdb,0xdb,0xea,0xdc,0xdf,0xd1,0x00};

//const unsigned char PY_mb_kui   []={"亏愧奎窥溃葵魁馈盔傀岿匮愦揆睽跬聩篑喹逵暌蒉悝喟馗蝰隗夔"};
const unsigned char PY_mb_kui   []={0xbf,0xf7,0xc0,0xa2,0xbf,0xfc,0xbf,0xfa,0xc0,0xa3,0xbf,0xfb,0xbf,0xfd,0xc0,0xa1,0xbf,0xf8,0xbf,0xfe,0xbf,0xf9,0xd8,0xd1,0xe3,0xb4,0xde,0xf1,0xee,0xa5,0xf5,0xcd,0xf1,0xf9,0xf3,0xf1,0xe0,0xad,0xe5,0xd3,0xea,0xd2,0xdd,0xde,0xe3,0xa6,0xe0,0xb0,0xd8,0xb8,0xf2,0xf1,0xda,0xf3,0xd9,0xe7,0x00};

//const unsigned char PY_mb_kun   []={"捆困昆坤鲲锟髡琨醌阃悃"};
const unsigned char PY_mb_kun   []={0xc0,0xa6,0xc0,0xa7,0xc0,0xa5,0xc0,0xa4,0xf6,0xef,0xef,0xbf,0xf7,0xd5,0xe7,0xfb,0xf5,0xab,0xe3,0xcd,0xe3,0xa7,0x00};

//const unsigned char PY_mb_kuo   []={"阔扩括廓适蛞栝"};
const unsigned char PY_mb_kuo   []={0xc0,0xab,0xc0,0xa9,0xc0,0xa8,0xc0,0xaa,0xca,0xca,0xf2,0xd2,0xe8,0xe9,0x00};

//const unsigned char PY_mb_la    []={"拉啦辣蜡腊喇垃蓝落瘌邋砬剌旯"};
const unsigned char PY_mb_la    []={0xc0,0xad,0xc0,0xb2,0xc0,0xb1,0xc0,0xaf,0xc0,0xb0,0xc0,0xae,0xc0,0xac,0xc0,0xb6,0xc2,0xe4,0xf0,0xf8,0xe5,0xe5,0xed,0xc7,0xd8,0xdd,0xea,0xb9,0x00};

//const unsigned char PY_mb_lai   []={"来赖莱崃徕涞濑赉睐铼癞籁"};
const unsigned char PY_mb_lai   []={0xc0,0xb4,0xc0,0xb5,0xc0,0xb3,0xe1,0xc1,0xe1,0xe2,0xe4,0xb5,0xe4,0xfe,0xea,0xe3,0xed,0xf9,0xef,0xaa,0xf1,0xae,0xf4,0xa5,0x00};

//const unsigned char PY_mb_lan   []={"蓝兰烂拦篮懒栏揽缆滥阑谰婪澜览榄岚褴镧斓罱漤"};
const unsigned char PY_mb_lan   []={0xc0,0xb6,0xc0,0xbc,0xc0,0xc3,0xc0,0xb9,0xc0,0xba,0xc0,0xc1,0xc0,0xb8,0xc0,0xbf,0xc0,0xc2,0xc0,0xc4,0xc0,0xbb,0xc0,0xbe,0xc0,0xb7,0xc0,0xbd,0xc0,0xc0,0xe9,0xad,0xe1,0xb0,0xf1,0xdc,0xef,0xe7,0xec,0xb5,0xee,0xbd,0xe4,0xed,0x00};

//const unsigned char PY_mb_lang  []={"浪狼廊郎朗榔琅稂螂莨啷锒阆蒗"};
const unsigned char PY_mb_lang  []={0xc0,0xcb,0xc0,0xc7,0xc0,0xc8,0xc0,0xc9,0xc0,0xca,0xc0,0xc6,0xc0,0xc5,0xef,0xfc,0xf2,0xeb,0xdd,0xb9,0xe0,0xa5,0xef,0xb6,0xe3,0xcf,0xdd,0xf5,0x00};

//const unsigned char PY_mb_lao   []={"老捞牢劳烙涝落姥酪络佬潦耢铹醪铑唠栳崂痨"};
const unsigned char PY_mb_lao   []={0xc0,0xcf,0xc0,0xcc,0xc0,0xce,0xc0,0xcd,0xc0,0xd3,0xc0,0xd4,0xc2,0xe4,0xc0,0xd1,0xc0,0xd2,0xc2,0xe7,0xc0,0xd0,0xc1,0xca,0xf1,0xec,0xef,0xa9,0xf5,0xb2,0xee,0xee,0xdf,0xeb,0xe8,0xe1,0xe1,0xc0,0xf0,0xec,0x00};

//const unsigned char PY_mb_le    []={"了乐勒肋仂叻泐鳓"};
const unsigned char PY_mb_le    []={0xc1,0xcb,0xc0,0xd6,0xc0,0xd5,0xc0,0xdf,0xd8,0xec,0xdf,0xb7,0xe3,0xee,0xf7,0xa6,0x00};

//const unsigned char PY_mb_lei   []={"类累泪雷垒勒擂蕾肋镭儡磊缧诔耒酹羸嫘檑嘞"};
const unsigned char PY_mb_lei   []={0xc0,0xe0,0xc0,0xdb,0xc0,0xe1,0xc0,0xd7,0xc0,0xdd,0xc0,0xd5,0xc0,0xde,0xc0,0xd9,0xc0,0xdf,0xc0,0xd8,0xc0,0xdc,0xc0,0xda,0xe7,0xd0,0xda,0xb3,0xf1,0xe7,0xf5,0xaa,0xd9,0xfa,0xe6,0xd0,0xe9,0xdb,0xe0,0xcf,0x00};

//const unsigned char PY_mb_leng  []={"冷棱楞塄愣"};
const unsigned char PY_mb_leng  []={0xc0,0xe4,0xc0,0xe2,0xc0,0xe3,0xdc,0xa8,0xe3,0xb6,0x00};

//const unsigned char PY_mb_li    []={"里离力立李例哩理利梨厘礼历丽吏犁黎篱狸漓鲤莉荔栗厉励砾傈俐痢粒沥隶璃俪俚郦坜苈莅蓠鹂笠鳢缡跞蜊锂悝澧粝枥蠡鬲呖砺嫠篥疠疬猁藜溧鲡戾栎唳醴轹詈骊罹逦喱雳黧蛎娌"};
const unsigned char PY_mb_li    []={0xc0,0xef,0xc0,0xeb,0xc1,0xa6,0xc1,0xa2,0xc0,0xee,0xc0,0xfd,0xc1,0xa8,0xc0,0xed,0xc0,0xfb,0xc0,0xe6,0xc0,0xe5,0xc0,0xf1,0xc0,0xfa,0xc0,0xf6,0xc0,0xf4,0xc0,0xe7,0xc0,0xe8,0xc0,0xe9,0xc0,0xea,0xc0,0xec,0xc0,0xf0,0xc0,0xf2,0xc0,0xf3,0xc0,0xf5,0xc0,0xf7,0xc0,0xf8,0xc0,0xf9,0xc0,0xfc,0xc0,0xfe,0xc1,0xa1,0xc1,0xa3,0xc1,0xa4,0xc1,0xa5,0xc1,0xa7,0xd9,0xb3,0xd9,0xb5,0xdb,0xaa,0xdb,0xde,0xdc,0xc2,0xdd,0xb0,0xdd,0xf1,0xf0,0xbf,0xf3,0xd2,0xf7,0xaf,0xe7,0xca,0xf5,0xc8,0xf2,0xdb,0xef,0xae,0xe3,0xa6,0xe5,0xa2,0xf4,0xcf,0xe8,0xc0,0xf3,0xbb,0xd8,0xaa,0xdf,0xbf,0xed,0xc2,0xe6,0xcb,0xf3,0xf6,0xf0,0xdd,0xf0,0xdf,0xe1,0xfb,0xde,0xbc,0xe4,0xe0,0xf6,0xe2,0xec,0xe5,0xe8,0xdd,0xe0,0xa6,0xf5,0xb7,0xe9,0xf6,0xee,0xba,0xe6,0xea,0xee,0xbe,0xe5,0xce,0xe0,0xac,0xf6,0xa8,0xf7,0xf3,0xf2,0xc3,0xe6,0xb2,0x00};

//const unsigned char PY_mb_lia	[]={"俩"};
const unsigned char PY_mb_lia	[]={0xc1,0xa9,0x00};

//const unsigned char PY_mb_lian  []={"连联练莲恋脸炼链敛怜廉帘镰涟蠊琏殓蔹鲢奁潋臁裢濂裣楝"};
const unsigned char PY_mb_lian  []={0xc1,0xac,0xc1,0xaa,0xc1,0xb7,0xc1,0xab,0xc1,0xb5,0xc1,0xb3,0xc1,0xb6,0xc1,0xb4,0xc1,0xb2,0xc1,0xaf,0xc1,0xae,0xc1,0xb1,0xc1,0xad,0xc1,0xb0,0xf3,0xb9,0xe7,0xf6,0xe9,0xe7,0xdd,0xfc,0xf6,0xe3,0xde,0xc6,0xe4,0xf2,0xec,0xa1,0xf1,0xcd,0xe5,0xa5,0xf1,0xcf,0xe9,0xac,0x00};

//const unsigned char PY_mb_liang []={"两亮辆凉粮梁量良晾谅俩粱墚靓踉椋魉莨"};
const unsigned char PY_mb_liang []={0xc1,0xbd,0xc1,0xc1,0xc1,0xbe,0xc1,0xb9,0xc1,0xb8,0xc1,0xba,0xc1,0xbf,0xc1,0xbc,0xc1,0xc0,0xc1,0xc2,0xc1,0xa9,0xc1,0xbb,0xdc,0xae,0xf6,0xa6,0xf5,0xd4,0xe9,0xa3,0xf7,0xcb,0xdd,0xb9,0x00};

//const unsigned char PY_mb_liao  []={"了料撩聊撂疗廖燎辽僚寥镣潦钌蓼尥寮缭獠鹩嘹"};
const unsigned char PY_mb_liao  []={0xc1,0xcb,0xc1,0xcf,0xc1,0xc3,0xc1,0xc4,0xc1,0xcc,0xc1,0xc6,0xc1,0xce,0xc1,0xc7,0xc1,0xc9,0xc1,0xc5,0xc1,0xc8,0xc1,0xcd,0xc1,0xca,0xee,0xc9,0xde,0xa4,0xde,0xcd,0xe5,0xbc,0xe7,0xd4,0xe2,0xb2,0xf0,0xd3,0xe0,0xda,0x00};

//const unsigned char PY_mb_lie   []={"列裂猎劣烈咧埒捩鬣趔躐冽洌"};
const unsigned char PY_mb_lie   []={0xc1,0xd0,0xc1,0xd1,0xc1,0xd4,0xc1,0xd3,0xc1,0xd2,0xdf,0xd6,0xdb,0xf8,0xde,0xe6,0xf7,0xe0,0xf4,0xf3,0xf5,0xf1,0xd9,0xfd,0xe4,0xa3,0x00};

//const unsigned char PY_mb_lin   []={"林临淋邻磷鳞赁吝拎琳霖凛遴嶙蔺粼麟躏辚廪懔瞵檩膦啉"};
const unsigned char PY_mb_lin   []={0xc1,0xd6,0xc1,0xd9,0xc1,0xdc,0xc1,0xda,0xc1,0xd7,0xc1,0xdb,0xc1,0xde,0xc1,0xdf,0xc1,0xe0,0xc1,0xd5,0xc1,0xd8,0xc1,0xdd,0xe5,0xe0,0xe1,0xd7,0xdd,0xfe,0xf4,0xd4,0xf7,0xeb,0xf5,0xef,0xea,0xa5,0xe2,0xde,0xe3,0xc1,0xee,0xac,0xe9,0xdd,0xec,0xa2,0xdf,0xf8,0x00};

//const unsigned char PY_mb_ling  []={"另令领零铃玲灵岭龄凌陵菱伶羚棱翎蛉苓绫瓴酃呤泠棂柃鲮聆囹"};
const unsigned char PY_mb_ling  []={0xc1,0xed,0xc1,0xee,0xc1,0xec,0xc1,0xe3,0xc1,0xe5,0xc1,0xe1,0xc1,0xe9,0xc1,0xeb,0xc1,0xe4,0xc1,0xe8,0xc1,0xea,0xc1,0xe2,0xc1,0xe6,0xc1,0xe7,0xc0,0xe2,0xf4,0xe1,0xf2,0xc8,0xdc,0xdf,0xe7,0xb1,0xea,0xb2,0xdb,0xb9,0xdf,0xca,0xe3,0xf6,0xe8,0xf9,0xe8,0xda,0xf6,0xec,0xf1,0xf6,0xe0,0xf2,0x00};

//const unsigned char PY_mb_liu   []={"六流留刘柳溜硫瘤榴琉馏碌陆绺锍鎏镏浏骝旒鹨熘遛"};
const unsigned char PY_mb_liu   []={0xc1,0xf9,0xc1,0xf7,0xc1,0xf4,0xc1,0xf5,0xc1,0xf8,0xc1,0xef,0xc1,0xf2,0xc1,0xf6,0xc1,0xf1,0xc1,0xf0,0xc1,0xf3,0xc2,0xb5,0xc2,0xbd,0xe7,0xb8,0xef,0xb3,0xf6,0xcc,0xef,0xd6,0xe4,0xaf,0xe6,0xf2,0xec,0xbc,0xf0,0xd2,0xec,0xd6,0xe5,0xde,0x00};

//const unsigned char PY_mb_long  []={"龙拢笼聋隆垄弄咙窿陇垅胧珑茏泷栊癃砻"};
const unsigned char PY_mb_long  []={0xc1,0xfa,0xc2,0xa3,0xc1,0xfd,0xc1,0xfb,0xc2,0xa1,0xc2,0xa2,0xc5,0xaa,0xc1,0xfc,0xc1,0xfe,0xc2,0xa4,0xdb,0xe2,0xeb,0xca,0xe7,0xe7,0xdc,0xd7,0xe3,0xf1,0xe8,0xd0,0xf1,0xaa,0xed,0xc3,0x00};

//const unsigned char PY_mb_lou   []={"楼搂漏陋露娄篓偻蝼镂蒌耧髅喽瘘嵝"};
const unsigned char PY_mb_lou   []={0xc2,0xa5,0xc2,0xa7,0xc2,0xa9,0xc2,0xaa,0xc2,0xb6,0xc2,0xa6,0xc2,0xa8,0xd9,0xcd,0xf2,0xf7,0xef,0xce,0xdd,0xe4,0xf1,0xef,0xf7,0xc3,0xe0,0xb6,0xf0,0xfc,0xe1,0xd0,0x00};

//const unsigned char PY_mb_lu    []={"路露录鹿陆炉卢鲁卤芦颅庐碌掳绿虏赂戮潞禄麓六鲈栌渌蓼逯泸轳氇簏橹辂垆胪噜"};
const unsigned char PY_mb_lu    []={0xc2,0xb7,0xc2,0xb6,0xc2,0xbc,0xc2,0xb9,0xc2,0xbd,0xc2,0xaf,0xc2,0xac,0xc2,0xb3,0xc2,0xb1,0xc2,0xab,0xc2,0xad,0xc2,0xae,0xc2,0xb5,0xc2,0xb0,0xc2,0xcc,0xc2,0xb2,0xc2,0xb8,0xc2,0xbe,0xc2,0xba,0xc2,0xbb,0xc2,0xb4,0xc1,0xf9,0xf6,0xd4,0xe8,0xd3,0xe4,0xcb,0xde,0xa4,0xe5,0xd6,0xe3,0xf2,0xe9,0xf1,0xeb,0xaa,0xf3,0xfc,0xe9,0xd6,0xe9,0xfb,0xdb,0xe4,0xeb,0xcd,0xe0,0xe0,0x00};

//const unsigned char PY_mb_luan  []={"乱卵滦峦孪挛栾銮脔娈鸾"};
const unsigned char PY_mb_luan  []={0xc2,0xd2,0xc2,0xd1,0xc2,0xd0,0xc2,0xcd,0xc2,0xcf,0xc2,0xce,0xe8,0xef,0xf6,0xc7,0xd9,0xf5,0xe6,0xae,0xf0,0xbd,0x00};

//const unsigned char PY_mb_lue   []={"略掠锊"};
const unsigned char PY_mb_lue   []={0xc2,0xd4,0xc2,0xd3,0xef,0xb2,0x00};

//const unsigned char PY_mb_lun   []={"论轮抡伦沦仑纶囵"};
const unsigned char PY_mb_lun   []={0xc2,0xdb,0xc2,0xd6,0xc2,0xd5,0xc2,0xd7,0xc2,0xd9,0xc2,0xd8,0xc2,0xda,0xe0,0xf0,0x00};

//const unsigned char PY_mb_luo   []={"落罗锣裸骡烙箩螺萝洛骆逻络咯荦漯蠃雒倮硌椤捋脶瘰摞泺珞镙猡"};
const unsigned char PY_mb_luo   []={0xc2,0xe4,0xc2,0xde,0xc2,0xe0,0xc2,0xe3,0xc2,0xe2,0xc0,0xd3,0xc2,0xe1,0xc2,0xdd,0xc2,0xdc,0xc2,0xe5,0xc2,0xe6,0xc2,0xdf,0xc2,0xe7,0xbf,0xa9,0xdc,0xfd,0xe4,0xf0,0xd9,0xf9,0xf6,0xc3,0xd9,0xc0,0xed,0xd1,0xe9,0xa1,0xde,0xdb,0xeb,0xe1,0xf1,0xa7,0xde,0xfb,0xe3,0xf8,0xe7,0xf3,0xef,0xdd,0xe2,0xa4,0x00};

//const unsigned char PY_mb_lv    []={"绿率铝驴旅屡滤吕律氯缕侣虑履偻膂榈闾捋褛稆"};
const unsigned char PY_mb_lv    []={0xc2,0xcc,0xc2,0xca,0xc2,0xc1,0xc2,0xbf,0xc2,0xc3,0xc2,0xc5,0xc2,0xcb,0xc2,0xc0,0xc2,0xc9,0xc2,0xc8,0xc2,0xc6,0xc2,0xc2,0xc2,0xc7,0xc2,0xc4,0xd9,0xcd,0xeb,0xf6,0xe9,0xb5,0xe3,0xcc,0xde,0xdb,0xf1,0xda,0xef,0xf9,0x00};

//const unsigned char PY_mb_ma    []={"吗妈马嘛麻骂抹码玛蚂摩唛蟆犸嬷杩"};
const unsigned char PY_mb_ma    []={0xc2,0xf0,0xc2,0xe8,0xc2,0xed,0xc2,0xef,0xc2,0xe9,0xc2,0xee,0xc4,0xa8,0xc2,0xeb,0xc2,0xea,0xc2,0xec,0xc4,0xa6,0xdf,0xe9,0xf3,0xa1,0xe1,0xef,0xe6,0xd6,0xe8,0xbf,0x00};

//const unsigned char PY_mb_mai   []={"买卖迈埋麦脉劢霾荬"};
const unsigned char PY_mb_mai   []={0xc2,0xf2,0xc2,0xf4,0xc2,0xf5,0xc2,0xf1,0xc2,0xf3,0xc2,0xf6,0xdb,0xbd,0xf6,0xb2,0xdd,0xa4,0x00};

//const unsigned char PY_mb_man   []={"满慢瞒漫蛮蔓曼馒埋谩幔鳗墁螨镘颟鞔缦熳"};
const unsigned char PY_mb_man   []={0xc2,0xfa,0xc2,0xfd,0xc2,0xf7,0xc2,0xfe,0xc2,0xf9,0xc2,0xfb,0xc2,0xfc,0xc2,0xf8,0xc2,0xf1,0xc3,0xa1,0xe1,0xa3,0xf7,0xa9,0xdc,0xac,0xf2,0xfd,0xef,0xdc,0xf2,0xa9,0xf7,0xb4,0xe7,0xcf,0xec,0xd7,0x00};

//const unsigned char PY_mb_mang  []={"忙芒盲莽茫氓硭邙蟒漭"};
const unsigned char PY_mb_mang  []={0xc3,0xa6,0xc3,0xa2,0xc3,0xa4,0xc3,0xa7,0xc3,0xa3,0xc3,0xa5,0xed,0xcb,0xda,0xf8,0xf2,0xfe,0xe4,0xdd,0x00};

//const unsigned char PY_mb_mao   []={"毛冒帽猫矛卯貌茂贸铆锚茅耄茆瑁蝥髦懋昴牦瞀峁袤蟊旄泖"};
const unsigned char PY_mb_mao   []={0xc3,0xab,0xc3,0xb0,0xc3,0xb1,0xc3,0xa8,0xc3,0xac,0xc3,0xae,0xc3,0xb2,0xc3,0xaf,0xc3,0xb3,0xc3,0xad,0xc3,0xaa,0xc3,0xa9,0xeb,0xa3,0xdc,0xe2,0xe8,0xa3,0xf2,0xfa,0xf7,0xd6,0xed,0xae,0xea,0xc4,0xea,0xf3,0xee,0xa6,0xe1,0xb9,0xd9,0xf3,0xf3,0xb1,0xec,0xb8,0xe3,0xf7,0x00};

//const unsigned char PY_mb_me    []={"么麽"};
const unsigned char PY_mb_me    []={0xc3,0xb4,0xf7,0xe1,0x00};

//const unsigned char PY_mb_mei   []={"没每煤镁美酶妹枚霉玫眉梅寐昧媒糜媚谜沫嵋猸袂湄浼鹛莓魅镅楣"};
const unsigned char PY_mb_mei   []={0xc3,0xbb,0xc3,0xbf,0xc3,0xba,0xc3,0xbe,0xc3,0xc0,0xc3,0xb8,0xc3,0xc3,0xc3,0xb6,0xc3,0xb9,0xc3,0xb5,0xc3,0xbc,0xc3,0xb7,0xc3,0xc2,0xc3,0xc1,0xc3,0xbd,0xc3,0xd3,0xc3,0xc4,0xc3,0xd5,0xc4,0xad,0xe1,0xd2,0xe2,0xad,0xf1,0xc7,0xe4,0xd8,0xe4,0xbc,0xf0,0xcc,0xdd,0xae,0xf7,0xc8,0xef,0xd1,0xe9,0xb9,0x00};

//const unsigned char PY_mb_men   []={"门们闷扪焖懑钔"};
const unsigned char PY_mb_men   []={0xc3,0xc5,0xc3,0xc7,0xc3,0xc6,0xde,0xd1,0xec,0xcb,0xed,0xaf,0xee,0xcd,0x00};

//const unsigned char PY_mb_meng  []={"猛梦蒙锰孟盟檬萌氓礞蜢勐懵甍蠓虻朦艋艨瞢"};
const unsigned char PY_mb_meng  []={0xc3,0xcd,0xc3,0xce,0xc3,0xc9,0xc3,0xcc,0xc3,0xcf,0xc3,0xcb,0xc3,0xca,0xc3,0xc8,0xc3,0xa5,0xed,0xe6,0xf2,0xec,0xdb,0xc2,0xe3,0xc2,0xdd,0xf9,0xf3,0xb7,0xf2,0xb5,0xeb,0xfc,0xf4,0xbb,0xf4,0xbf,0xde,0xab,0x00};

//const unsigned char PY_mb_mi    []={"米密迷眯蜜谜觅秘弥幂靡糜泌醚蘼縻咪汨麋祢猕弭谧芈脒宓敉嘧糸"};
const unsigned char PY_mb_mi    []={0xc3,0xd7,0xc3,0xdc,0xc3,0xd4,0xc3,0xd0,0xc3,0xdb,0xc3,0xd5,0xc3,0xd9,0xc3,0xd8,0xc3,0xd6,0xc3,0xdd,0xc3,0xd2,0xc3,0xd3,0xc3,0xda,0xc3,0xd1,0xde,0xc2,0xf7,0xe3,0xdf,0xe4,0xe3,0xe8,0xf7,0xe7,0xec,0xf2,0xe2,0xa8,0xe5,0xf4,0xda,0xd7,0xd8,0xc2,0xeb,0xdf,0xe5,0xb5,0xf4,0xcd,0xe0,0xd7,0xf4,0xe9,0x00};

//const unsigned char PY_mb_mian  []={"面棉免绵眠缅勉冕娩腼湎眄沔黾渑"};
const unsigned char PY_mb_mian  []={0xc3,0xe6,0xc3,0xde,0xc3,0xe2,0xc3,0xe0,0xc3,0xdf,0xc3,0xe5,0xc3,0xe3,0xc3,0xe1,0xc3,0xe4,0xeb,0xef,0xe4,0xcf,0xed,0xed,0xe3,0xe6,0xf6,0xbc,0xe4,0xc5,0x00};

//const unsigned char PY_mb_miao  []={"秒苗庙妙描瞄藐渺眇缪缈邈淼喵杪鹋"};
const unsigned char PY_mb_miao  []={0xc3,0xeb,0xc3,0xe7,0xc3,0xed,0xc3,0xee,0xc3,0xe8,0xc3,0xe9,0xc3,0xea,0xc3,0xec,0xed,0xf0,0xe7,0xd1,0xe7,0xbf,0xe5,0xe3,0xed,0xb5,0xdf,0xf7,0xe8,0xc2,0xf0,0xc5,0x00};

//const unsigned char PY_mb_mie   []={"灭蔑咩篾蠛乜"};
const unsigned char PY_mb_mie   []={0xc3,0xf0,0xc3,0xef,0xdf,0xe3,0xf3,0xfa,0xf3,0xba,0xd8,0xbf,0x00};

//const unsigned char PY_mb_min   []={"民抿敏闽皿悯珉愍缗闵玟苠泯黾鳘岷"};
const unsigned char PY_mb_min   []={0xc3,0xf1,0xc3,0xf2,0xc3,0xf4,0xc3,0xf6,0xc3,0xf3,0xc3,0xf5,0xe7,0xeb,0xed,0xaa,0xe7,0xc5,0xe3,0xc9,0xe7,0xe4,0xdc,0xe5,0xe3,0xfd,0xf6,0xbc,0xf7,0xaa,0xe1,0xba,0x00};

//const unsigned char PY_mb_ming  []={"名明命鸣铭螟盟冥瞑暝茗溟酩"};
const unsigned char PY_mb_ming  []={0xc3,0xfb,0xc3,0xf7,0xc3,0xfc,0xc3,0xf9,0xc3,0xfa,0xc3,0xf8,0xc3,0xcb,0xda,0xa4,0xee,0xa8,0xea,0xd4,0xdc,0xf8,0xe4,0xe9,0xf5,0xa4,0x00};

//const unsigned char PY_mb_miu   []={"谬缪"};
const unsigned char PY_mb_miu   []={0xc3,0xfd,0xe7,0xd1,0x00};

//const unsigned char PY_mb_mo    []={"摸磨抹末膜墨没莫默魔模摩摹漠陌脉沫万无冒寞秣蓦麽茉嘿嬷蘑瘼殁镆嫫谟貊貘馍耱"};
const unsigned char PY_mb_mo    []={0xc3,0xfe,0xc4,0xa5,0xc4,0xa8,0xc4,0xa9,0xc4,0xa4,0xc4,0xab,0xc3,0xbb,0xc4,0xaa,0xc4,0xac,0xc4,0xa7,0xc4,0xa3,0xc4,0xa6,0xc4,0xa1,0xc4,0xae,0xc4,0xb0,0xc2,0xf6,0xc4,0xad,0xcd,0xf2,0xce,0xde,0xc3,0xb0,0xc4,0xaf,0xef,0xf7,0xdd,0xeb,0xf7,0xe1,0xdc,0xd4,0xba,0xd9,0xe6,0xd6,0xc4,0xa2,0xf1,0xa2,0xe9,0xe2,0xef,0xd2,0xe6,0xc6,0xda,0xd3,0xf5,0xf6,0xf5,0xf8,0xe2,0xc9,0xf1,0xf2,0x00};

//const unsigned char PY_mb_mou   []={"某谋牟眸蛑鍪侔缪哞"};
const unsigned char PY_mb_mou   []={0xc4,0xb3,0xc4,0xb1,0xc4,0xb2,0xed,0xf8,0xf2,0xd6,0xf6,0xca,0xd9,0xb0,0xe7,0xd1,0xdf,0xe8,0x00};

//const unsigned char PY_mb_mu    []={"木母亩幕目墓牧牟模穆暮牡拇募慕睦姆姥钼毪坶沐仫苜"};
const unsigned char PY_mb_mu    []={0xc4,0xbe,0xc4,0xb8,0xc4,0xb6,0xc4,0xbb,0xc4,0xbf,0xc4,0xb9,0xc4,0xc1,0xc4,0xb2,0xc4,0xa3,0xc4,0xc2,0xc4,0xba,0xc4,0xb5,0xc4,0xb4,0xc4,0xbc,0xc4,0xbd,0xc4,0xc0,0xc4,0xb7,0xc0,0xd1,0xee,0xe2,0xeb,0xa4,0xdb,0xe9,0xe3,0xe5,0xd8,0xef,0xdc,0xd9,0x00};

//const unsigned char PY_mb_na    []={"那拿哪纳钠娜呐南衲捺镎肭"};
const unsigned char PY_mb_na    []={0xc4,0xc7,0xc4,0xc3,0xc4,0xc4,0xc4,0xc9,0xc4,0xc6,0xc4,0xc8,0xc4,0xc5,0xc4,0xcf,0xf1,0xc4,0xde,0xe0,0xef,0xd5,0xeb,0xc7,0x00};

//const unsigned char PY_mb_nai   []={"乃耐奶奈氖哪萘艿柰鼐佴"};
const unsigned char PY_mb_nai   []={0xc4,0xcb,0xc4,0xcd,0xc4,0xcc,0xc4,0xce,0xc4,0xca,0xc4,0xc4,0xdd,0xc1,0xdc,0xb5,0xe8,0xcd,0xd8,0xbe,0xd9,0xa6,0x00};

//const unsigned char PY_mb_nan   []={"难南男赧囡蝻楠喃腩"};
const unsigned char PY_mb_nan   []={0xc4,0xd1,0xc4,0xcf,0xc4,0xd0,0xf4,0xf6,0xe0,0xef,0xf2,0xef,0xe9,0xaa,0xe0,0xab,0xeb,0xee,0x00};

//const unsigned char PY_mb_nang  []={"囊馕曩囔攮"};
const unsigned char PY_mb_nang  []={0xc4,0xd2,0xe2,0xce,0xea,0xd9,0xe0,0xec,0xdf,0xad,0x00};

//const unsigned char PY_mb_nao   []={"闹脑恼挠淖孬铙瑙垴呶蛲猱硇"};
const unsigned char PY_mb_nao   []={0xc4,0xd6,0xc4,0xd4,0xc4,0xd5,0xc4,0xd3,0xc4,0xd7,0xd8,0xab,0xee,0xf3,0xe8,0xa7,0xdb,0xf1,0xdf,0xce,0xf2,0xcd,0xe2,0xae,0xed,0xd0,0x00};

//const unsigned char PY_mb_ne    []={"呢哪那呐讷"};
const unsigned char PY_mb_ne    []={0xc4,0xd8,0xc4,0xc4,0xc4,0xc7,0xc4,0xc5,0xda,0xab,0x00};

//const unsigned char PY_mb_nei   []={"内哪馁那"};
const unsigned char PY_mb_nei   []={0xc4,0xda,0xc4,0xc4,0xc4,0xd9,0xc4,0xc7,0x00};

//const unsigned char PY_mb_nen   []={"嫩恁"};
const unsigned char PY_mb_nen   []={0xc4,0xdb,0xed,0xa5,0x00};

//const unsigned char PY_mb_neng  []={"能"};
const unsigned char PY_mb_neng  []={0xc4,0xdc,0x00};

//const unsigned char PY_mb_ni    []={"你泥拟腻逆呢溺倪尼匿妮霓铌昵坭祢猊伲怩鲵睨旎"};
const unsigned char PY_mb_ni    []={0xc4,0xe3,0xc4,0xe0,0xc4,0xe2,0xc4,0xe5,0xc4,0xe6,0xc4,0xd8,0xc4,0xe7,0xc4,0xdf,0xc4,0xe1,0xc4,0xe4,0xc4,0xdd,0xc4,0xde,0xee,0xea,0xea,0xc7,0xdb,0xe8,0xec,0xf2,0xe2,0xa5,0xd9,0xa3,0xe2,0xf5,0xf6,0xf2,0xed,0xfe,0xec,0xbb,0x00};

//const unsigned char PY_mb_nian  []={"年念捻撵拈碾蔫粘廿黏辇鲇鲶埝"};
const unsigned char PY_mb_nian  []={0xc4,0xea,0xc4,0xee,0xc4,0xed,0xc4,0xec,0xc4,0xe9,0xc4,0xeb,0xc4,0xe8,0xd5,0xb3,0xd8,0xa5,0xf0,0xa4,0xe9,0xfd,0xf6,0xd3,0xf6,0xf3,0xdb,0xfe,0x00};

//const unsigned char PY_mb_niang []={"娘酿"};
const unsigned char PY_mb_niang []={0xc4,0xef,0xc4,0xf0,0x00};

//const unsigned char PY_mb_niao  []={"鸟尿袅茑脲嬲"};
const unsigned char PY_mb_niao  []={0xc4,0xf1,0xc4,0xf2,0xf4,0xc1,0xdc,0xe0,0xeb,0xe5,0xe6,0xd5,0x00};

//const unsigned char PY_mb_nie   []={"捏镍聂孽涅镊啮陧蘖嗫臬蹑颞乜"};
const unsigned char PY_mb_nie   []={0xc4,0xf3,0xc4,0xf8,0xc4,0xf4,0xc4,0xf5,0xc4,0xf9,0xc4,0xf7,0xc4,0xf6,0xda,0xed,0xde,0xc1,0xe0,0xbf,0xf4,0xab,0xf5,0xe6,0xf2,0xa8,0xd8,0xbf,0x00};

//const unsigned char PY_mb_nin   []={"您恁"};
const unsigned char PY_mb_nin   []={0xc4,0xfa,0xed,0xa5,0x00};

//const unsigned char PY_mb_ning  []={"拧凝宁柠狞泞佞甯咛聍"};
const unsigned char PY_mb_ning  []={0xc5,0xa1,0xc4,0xfd,0xc4,0xfe,0xc4,0xfb,0xc4,0xfc,0xc5,0xa2,0xd8,0xfa,0xe5,0xb8,0xdf,0xcc,0xf1,0xf7,0x00};

//const unsigned char PY_mb_niu   []={"牛扭纽钮狃忸妞拗"};
const unsigned char PY_mb_niu   []={0xc5,0xa3,0xc5,0xa4,0xc5,0xa6,0xc5,0xa5,0xe1,0xf0,0xe2,0xee,0xe6,0xa4,0xde,0xd6,0x00};

//const unsigned char PY_mb_nong  []={"弄浓农脓哝侬"};
const unsigned char PY_mb_nong  []={0xc5,0xaa,0xc5,0xa8,0xc5,0xa9,0xc5,0xa7,0xdf,0xe6,0xd9,0xaf,0x00};

//const unsigned char PY_mb_nu    []={"怒努奴孥胬驽弩"};
const unsigned char PY_mb_nu    []={0xc5,0xad,0xc5,0xac,0xc5,0xab,0xe6,0xdb,0xe6,0xc0,0xe6,0xe5,0xe5,0xf3,0x00};

//const unsigned char PY_mb_nuan  []={"暖"};
const unsigned char PY_mb_nuan  []={0xc5,0xaf,0x00};

//const unsigned char PY_mb_nue   []={"虐疟谑"};
const unsigned char PY_mb_nue   []={0xc5,0xb0,0xc5,0xb1,0xda,0xca,0x00};

//const unsigned char PY_mb_nuo   []={"挪诺懦糯娜喏傩锘搦"};
const unsigned char PY_mb_nuo   []={0xc5,0xb2,0xc5,0xb5,0xc5,0xb3,0xc5,0xb4,0xc4,0xc8,0xdf,0xf6,0xd9,0xd0,0xef,0xbb,0xde,0xf9,0x00};

//const unsigned char PY_mb_nv    []={"女钕恧衄"};
const unsigned char PY_mb_nv    []={0xc5,0xae,0xee,0xcf,0xed,0xa4,0xf4,0xac,0x00};

//const unsigned char PY_mb_o     []={"哦喔噢"};
const unsigned char PY_mb_o     []={0xc5,0xb6,0xe0,0xb8,0xe0,0xde,0x00};

//const unsigned char PY_mb_ou    []={"偶呕欧藕鸥区沤殴怄瓯讴耦"};
const unsigned char PY_mb_ou    []={0xc5,0xbc,0xc5,0xbb,0xc5,0xb7,0xc5,0xba,0xc5,0xb8,0xc7,0xf8,0xc5,0xbd,0xc5,0xb9,0xe2,0xe6,0xea,0xb1,0xda,0xa9,0xf1,0xee,0x00};

//const unsigned char PY_mb_pa    []={"怕爬趴啪耙扒帕琶派筢杷葩"};
const unsigned char PY_mb_pa    []={0xc5,0xc2,0xc5,0xc0,0xc5,0xbf,0xc5,0xbe,0xb0,0xd2,0xb0,0xc7,0xc5,0xc1,0xc5,0xc3,0xc5,0xc9,0xf3,0xe1,0xe8,0xcb,0xdd,0xe2,0x00};

//const unsigned char PY_mb_pai   []={"派排拍牌迫徘湃哌俳蒎"};
const unsigned char PY_mb_pai   []={0xc5,0xc9,0xc5,0xc5,0xc5,0xc4,0xc5,0xc6,0xc6,0xc8,0xc5,0xc7,0xc5,0xc8,0xdf,0xdf,0xd9,0xbd,0xdd,0xe5,0x00};

//const unsigned char PY_mb_pan   []={"盘盼判攀畔潘叛磐番般胖襻蟠袢泮拚爿蹒"};
const unsigned char PY_mb_pan   []={0xc5,0xcc,0xc5,0xce,0xc5,0xd0,0xc5,0xca,0xc5,0xcf,0xc5,0xcb,0xc5,0xd1,0xc5,0xcd,0xb7,0xac,0xb0,0xe3,0xc5,0xd6,0xf1,0xe1,0xf3,0xb4,0xf1,0xc8,0xe3,0xfa,0xde,0xd5,0xe3,0xdd,0xf5,0xe7,0x00};

//const unsigned char PY_mb_pang  []={"旁胖耪庞乓膀磅滂彷逄螃"};
const unsigned char PY_mb_pang  []={0xc5,0xd4,0xc5,0xd6,0xc5,0xd5,0xc5,0xd3,0xc5,0xd2,0xb0,0xf2,0xb0,0xf5,0xe4,0xe8,0xe1,0xdd,0xe5,0xcc,0xf3,0xa6,0x00};

//const unsigned char PY_mb_pao   []={"跑抛炮泡刨袍咆狍匏庖疱脬"};
const unsigned char PY_mb_pao   []={0xc5,0xdc,0xc5,0xd7,0xc5,0xda,0xc5,0xdd,0xc5,0xd9,0xc5,0xdb,0xc5,0xd8,0xe1,0xf3,0xde,0xcb,0xe2,0xd2,0xf0,0xe5,0xeb,0xe3,0x00};

//const unsigned char PY_mb_pei   []={"陪配赔呸胚佩培沛裴旆锫帔醅霈辔"};
const unsigned char PY_mb_pei   []={0xc5,0xe3,0xc5,0xe4,0xc5,0xe2,0xc5,0xde,0xc5,0xdf,0xc5,0xe5,0xc5,0xe0,0xc5,0xe6,0xc5,0xe1,0xec,0xb7,0xef,0xc2,0xe0,0xfa,0xf5,0xac,0xf6,0xac,0xe0,0xce,0x00};

//const unsigned char PY_mb_pen   []={"喷盆湓"};
const unsigned char PY_mb_pen   []={0xc5,0xe7,0xc5,0xe8,0xe4,0xd4,0x00};

//const unsigned char PY_mb_peng  []={"碰捧棚砰蓬朋彭鹏烹硼膨抨澎篷怦堋蟛嘭"};
const unsigned char PY_mb_peng  []={0xc5,0xf6,0xc5,0xf5,0xc5,0xef,0xc5,0xe9,0xc5,0xee,0xc5,0xf3,0xc5,0xed,0xc5,0xf4,0xc5,0xeb,0xc5,0xf0,0xc5,0xf2,0xc5,0xea,0xc5,0xec,0xc5,0xf1,0xe2,0xf1,0xdc,0xa1,0xf3,0xb2,0xe0,0xd8,0x00};

//const unsigned char PY_mb_pi    []={"批皮披匹劈辟坯屁脾僻疲痞霹琵毗啤譬砒否貔丕圮媲癖仳擗郫甓枇睥蜱鼙邳吡陂铍庀罴埤纰陴淠噼蚍裨"};
const unsigned char PY_mb_pi    []={0xc5,0xfa,0xc6,0xa4,0xc5,0xfb,0xc6,0xa5,0xc5,0xfc,0xb1,0xd9,0xc5,0xf7,0xc6,0xa8,0xc6,0xa2,0xc6,0xa7,0xc6,0xa3,0xc6,0xa6,0xc5,0xf9,0xc5,0xfd,0xc5,0xfe,0xc6,0xa1,0xc6,0xa9,0xc5,0xf8,0xb7,0xf1,0xf5,0xf9,0xd8,0xa7,0xdb,0xdc,0xe6,0xc7,0xf1,0xb1,0xd8,0xf2,0xdf,0xa8,0xdb,0xaf,0xea,0xb6,0xe8,0xc1,0xee,0xa2,0xf2,0xe7,0xdc,0xb1,0xda,0xfc,0xdf,0xc1,0xda,0xe9,0xee,0xeb,0xe2,0xcf,0xee,0xbc,0xdb,0xfd,0xe7,0xa2,0xda,0xf0,0xe4,0xc4,0xe0,0xe8,0xf2,0xb7,0xf1,0xd4,0x00};

//const unsigned char PY_mb_pian  []={"片篇骗偏便扁翩缏犏骈胼蹁谝"};
const unsigned char PY_mb_pian  []={0xc6,0xac,0xc6,0xaa,0xc6,0xad,0xc6,0xab,0xb1,0xe3,0xb1,0xe2,0xf4,0xe6,0xe7,0xc2,0xea,0xfa,0xe6,0xe9,0xeb,0xdd,0xf5,0xe4,0xda,0xd2,0x00};

//const unsigned char PY_mb_piao  []={"票飘漂瓢朴螵莩嫖瞟殍缥嘌骠剽"};
const unsigned char PY_mb_piao  []={0xc6,0xb1,0xc6,0xae,0xc6,0xaf,0xc6,0xb0,0xc6,0xd3,0xf3,0xaa,0xdd,0xb3,0xe6,0xce,0xee,0xa9,0xe9,0xe8,0xe7,0xce,0xe0,0xd1,0xe6,0xf4,0xd8,0xe2,0x00};

//const unsigned char PY_mb_pie   []={"瞥撇苤氕"};
const unsigned char PY_mb_pie   []={0xc6,0xb3,0xc6,0xb2,0xdc,0xd6,0xeb,0xad,0x00};

//const unsigned char PY_mb_pin   []={"品贫聘拼频嫔榀姘牝颦"};
const unsigned char PY_mb_pin   []={0xc6,0xb7,0xc6,0xb6,0xc6,0xb8,0xc6,0xb4,0xc6,0xb5,0xe6,0xc9,0xe9,0xaf,0xe6,0xb0,0xea,0xf2,0xf2,0xad,0x00};

//const unsigned char PY_mb_ping  []={"平凭瓶评屏乒萍苹坪冯娉鲆枰俜"};
const unsigned char PY_mb_ping  []={0xc6,0xbd,0xc6,0xbe,0xc6,0xbf,0xc6,0xc0,0xc6,0xc1,0xc6,0xb9,0xc6,0xbc,0xc6,0xbb,0xc6,0xba,0xb7,0xeb,0xe6,0xb3,0xf6,0xd2,0xe8,0xd2,0xd9,0xb7,0x00};

//const unsigned char PY_mb_po    []={"破坡颇婆泼迫泊魄朴繁粕笸皤钋陂鄱攴叵珀钷"};
const unsigned char PY_mb_po    []={0xc6,0xc6,0xc6,0xc2,0xc6,0xc4,0xc6,0xc5,0xc6,0xc3,0xc6,0xc8,0xb2,0xb4,0xc6,0xc7,0xc6,0xd3,0xb7,0xb1,0xc6,0xc9,0xf3,0xcd,0xf0,0xab,0xee,0xc7,0xda,0xe9,0xdb,0xb6,0xea,0xb7,0xd8,0xcf,0xe7,0xea,0xee,0xde,0x00};

//const unsigned char PY_mb_pou   []={"剖掊裒"};
const unsigned char PY_mb_pou   []={0xc6,0xca,0xde,0xe5,0xd9,0xf6,0x00};

//const unsigned char PY_mb_pu    []={"扑铺谱脯仆蒲葡朴菩曝莆瀑埔圃浦堡普暴镨噗匍溥濮氆蹼璞镤僕"};
const unsigned char PY_mb_pu    []={0xc6,0xcb,0xc6,0xcc,0xc6,0xd7,0xb8,0xac,0xc6,0xcd,0xc6,0xd1,0xc6,0xcf,0xc6,0xd3,0xc6,0xd0,0xc6,0xd8,0xc6,0xce,0xc6,0xd9,0xc6,0xd2,0xc6,0xd4,0xc6,0xd6,0xb1,0xa4,0xc6,0xd5,0xb1,0xa9,0xef,0xe8,0xe0,0xdb,0xd9,0xe9,0xe4,0xdf,0xe5,0xa7,0xeb,0xab,0xf5,0xeb,0xe8,0xb1,0xef,0xe4,0x83,0x57,0x00};

//const unsigned char PY_mb_qi    []={"起其七气期齐器妻骑汽棋奇欺漆启戚柒岂砌弃泣祁凄企乞契歧祈栖畦脐崎稽迄缉沏讫旗祺颀骐屺岐蹊萁蕲桤憩芪荠萋芑汔亟鳍俟槭嘁蛴綦亓欹琪麒琦蜞圻杞葺碛淇祗耆绮"};
const unsigned char PY_mb_qi    []={0xc6,0xf0,0xc6,0xe4,0xc6,0xdf,0xc6,0xf8,0xc6,0xda,0xc6,0xeb,0xc6,0xf7,0xc6,0xde,0xc6,0xef,0xc6,0xfb,0xc6,0xe5,0xc6,0xe6,0xc6,0xdb,0xc6,0xe1,0xc6,0xf4,0xc6,0xdd,0xc6,0xe2,0xc6,0xf1,0xc6,0xf6,0xc6,0xfa,0xc6,0xfc,0xc6,0xee,0xc6,0xe0,0xc6,0xf3,0xc6,0xf2,0xc6,0xf5,0xc6,0xe7,0xc6,0xed,0xc6,0xdc,0xc6,0xe8,0xc6,0xea,0xc6,0xe9,0xbb,0xfc,0xc6,0xf9,0xbc,0xa9,0xc6,0xe3,0xc6,0xfd,0xc6,0xec,0xec,0xf7,0xf1,0xfd,0xe6,0xeb,0xe1,0xa8,0xe1,0xaa,0xf5,0xe8,0xdd,0xbd,0xde,0xad,0xe8,0xe7,0xed,0xac,0xdc,0xce,0xdc,0xf9,0xdd,0xc2,0xdc,0xbb,0xe3,0xe0,0xd8,0xbd,0xf7,0xa2,0xd9,0xb9,0xe9,0xca,0xe0,0xd2,0xf2,0xd3,0xf4,0xeb,0xd8,0xc1,0xec,0xa5,0xe7,0xf7,0xf7,0xe8,0xe7,0xf9,0xf2,0xe0,0xdb,0xdf,0xe8,0xbd,0xdd,0xdd,0xed,0xd3,0xe4,0xbf,0xec,0xf3,0xea,0xc8,0xe7,0xb2,0x00};

//const unsigned char PY_mb_qia   []={"恰卡掐洽袷葜髂"};
const unsigned char PY_mb_qia   []={0xc7,0xa1,0xbf,0xa8,0xc6,0xfe,0xc7,0xa2,0xf1,0xca,0xdd,0xd6,0xf7,0xc4,0x00};

//const unsigned char PY_mb_qian  []={"前钱千牵浅签欠铅嵌钎迁钳乾谴谦潜歉纤扦遣黔堑仟岍钤褰箝掮搴倩慊悭愆虔芡荨缱佥芊阡肷茜椠犍骞"};
const unsigned char PY_mb_qian  []={0xc7,0xb0,0xc7,0xae,0xc7,0xa7,0xc7,0xa3,0xc7,0xb3,0xc7,0xa9,0xc7,0xb7,0xc7,0xa6,0xc7,0xb6,0xc7,0xa5,0xc7,0xa8,0xc7,0xaf,0xc7,0xac,0xc7,0xb4,0xc7,0xab,0xc7,0xb1,0xc7,0xb8,0xcf,0xcb,0xc7,0xa4,0xc7,0xb2,0xc7,0xad,0xc7,0xb5,0xc7,0xaa,0xe1,0xa9,0xee,0xd4,0xe5,0xbd,0xf3,0xe9,0xde,0xe7,0xe5,0xba,0xd9,0xbb,0xe3,0xbb,0xe3,0xa5,0xed,0xa9,0xf2,0xaf,0xdc,0xcd,0xdd,0xa1,0xe7,0xd7,0xd9,0xdd,0xdc,0xb7,0xda,0xe4,0xeb,0xc9,0xdc,0xe7,0xe8,0xfd,0xea,0xf9,0xe5,0xb9,0x00};

//const unsigned char PY_mb_qiang []={"强枪墙抢腔呛羌蔷将蜣跄戗襁戕炝镪锖锵羟樯嫱"};
const unsigned char PY_mb_qiang []={0xc7,0xbf,0xc7,0xb9,0xc7,0xbd,0xc7,0xc0,0xc7,0xbb,0xc7,0xba,0xc7,0xbc,0xc7,0xbe,0xbd,0xab,0xf2,0xde,0xf5,0xc4,0xea,0xa8,0xf1,0xdf,0xe3,0xde,0xec,0xc1,0xef,0xea,0xef,0xba,0xef,0xcf,0xf4,0xc7,0xe9,0xc9,0xe6,0xcd,0x00};

//const unsigned char PY_mb_qiao  []={"桥瞧敲巧翘锹壳鞘撬悄俏窍雀乔侨峭橇樵荞跷硗憔谯鞒愀缲诮劁"};
const unsigned char PY_mb_qiao  []={0xc7,0xc5,0xc7,0xc6,0xc7,0xc3,0xc7,0xc9,0xc7,0xcc,0xc7,0xc2,0xbf,0xc7,0xc7,0xca,0xc7,0xcb,0xc7,0xc4,0xc7,0xce,0xc7,0xcf,0xc8,0xb8,0xc7,0xc7,0xc7,0xc8,0xc7,0xcd,0xc7,0xc1,0xe9,0xd4,0xdc,0xf1,0xf5,0xce,0xed,0xcd,0xe3,0xbe,0xda,0xdb,0xf7,0xb3,0xe3,0xb8,0xe7,0xd8,0xda,0xbd,0xd8,0xe4,0x00};

//const unsigned char PY_mb_qie   []={"切且怯窃茄砌郄趄惬锲妾箧慊伽挈"};
const unsigned char PY_mb_qie   []={0xc7,0xd0,0xc7,0xd2,0xc7,0xd3,0xc7,0xd4,0xc7,0xd1,0xc6,0xf6,0xdb,0xa7,0xf4,0xf2,0xe3,0xab,0xef,0xc6,0xe6,0xaa,0xf3,0xe6,0xe3,0xbb,0xd9,0xa4,0xea,0xfc,0x00};

//const unsigned char PY_mb_qin   []={"亲琴侵勤擒寝秦芹沁禽钦吣覃矜衾芩溱廑嗪螓噙揿檎锓"};
const unsigned char PY_mb_qin   []={0xc7,0xd7,0xc7,0xd9,0xc7,0xd6,0xc7,0xda,0xc7,0xdc,0xc7,0xde,0xc7,0xd8,0xc7,0xdb,0xc7,0xdf,0xc7,0xdd,0xc7,0xd5,0xdf,0xc4,0xf1,0xfb,0xf1,0xe6,0xf4,0xc0,0xdc,0xcb,0xe4,0xda,0xe2,0xdb,0xe0,0xba,0xf2,0xfb,0xe0,0xdf,0xde,0xec,0xe9,0xd5,0xef,0xb7,0x00};

//const unsigned char PY_mb_qing  []={"请轻清青情晴氢倾庆擎顷亲卿氰圊謦檠箐苘蜻黥罄鲭磬綮"};
const unsigned char PY_mb_qing  []={0xc7,0xeb,0xc7,0xe1,0xc7,0xe5,0xc7,0xe0,0xc7,0xe9,0xc7,0xe7,0xc7,0xe2,0xc7,0xe3,0xc7,0xec,0xc7,0xe6,0xc7,0xea,0xc7,0xd7,0xc7,0xe4,0xc7,0xe8,0xe0,0xf5,0xf6,0xa5,0xe9,0xd1,0xf3,0xe4,0xdc,0xdc,0xf2,0xdf,0xf7,0xf4,0xf3,0xc0,0xf6,0xeb,0xed,0xe0,0xf4,0xec,0x00};

//const unsigned char PY_mb_qiong []={"穷琼跫穹邛蛩茕銎筇"};
const unsigned char PY_mb_qiong []={0xc7,0xee,0xc7,0xed,0xf5,0xbc,0xf1,0xb7,0xda,0xf6,0xf2,0xcb,0xdc,0xe4,0xf6,0xc6,0xf3,0xcc,0x00};

//const unsigned char PY_mb_qiu   []={"求球秋丘泅仇邱囚酋龟楸蚯裘糗蝤巯逑俅虬赇鳅犰湫鼽遒"};
const unsigned char PY_mb_qiu   []={0xc7,0xf3,0xc7,0xf2,0xc7,0xef,0xc7,0xf0,0xc7,0xf6,0xb3,0xf0,0xc7,0xf1,0xc7,0xf4,0xc7,0xf5,0xb9,0xea,0xe9,0xb1,0xf2,0xc7,0xf4,0xc3,0xf4,0xdc,0xf2,0xf8,0xdb,0xcf,0xe5,0xcf,0xd9,0xb4,0xf2,0xb0,0xea,0xe4,0xf6,0xfa,0xe1,0xec,0xe4,0xd0,0xf7,0xfc,0xe5,0xd9,0x00};

//const unsigned char PY_mb_qu    []={"去取区娶渠曲趋趣屈驱蛆躯龋戌蠼蘧祛蕖磲劬诎鸲阒麴癯衢黢璩氍觑蛐朐瞿岖苣"};
const unsigned char PY_mb_qu    []={0xc8,0xa5,0xc8,0xa1,0xc7,0xf8,0xc8,0xa2,0xc7,0xfe,0xc7,0xfa,0xc7,0xf7,0xc8,0xa4,0xc7,0xfc,0xc7,0xfd,0xc7,0xf9,0xc7,0xfb,0xc8,0xa3,0xd0,0xe7,0xf3,0xbd,0xde,0xbe,0xec,0xee,0xde,0xa1,0xed,0xe1,0xdb,0xbe,0xda,0xb0,0xf0,0xb6,0xe3,0xd6,0xf4,0xf0,0xf1,0xb3,0xe1,0xe9,0xf7,0xf1,0xe8,0xb3,0xeb,0xac,0xea,0xef,0xf2,0xd0,0xeb,0xd4,0xf6,0xc4,0xe1,0xab,0xdc,0xc4,0x00};

//const unsigned char PY_mb_quan  []={"全权劝圈拳犬泉券颧痊醛铨筌绻诠辁畎鬈悛蜷荃"};
const unsigned char PY_mb_quan  []={0xc8,0xab,0xc8,0xa8,0xc8,0xb0,0xc8,0xa6,0xc8,0xad,0xc8,0xae,0xc8,0xaa,0xc8,0xaf,0xc8,0xa7,0xc8,0xac,0xc8,0xa9,0xee,0xfd,0xf3,0xdc,0xe7,0xb9,0xda,0xb9,0xe9,0xfa,0xee,0xb0,0xf7,0xdc,0xe3,0xaa,0xf2,0xe9,0xdc,0xf5,0x00};

//const unsigned char PY_mb_que   []={"却缺确雀瘸鹊炔榷阙阕悫"};
const unsigned char PY_mb_que   []={0xc8,0xb4,0xc8,0xb1,0xc8,0xb7,0xc8,0xb8,0xc8,0xb3,0xc8,0xb5,0xc8,0xb2,0xc8,0xb6,0xe3,0xda,0xe3,0xd7,0xed,0xa8,0x00};

//const unsigned char PY_mb_qun   []={"群裙逡麇"};
const unsigned char PY_mb_qun   []={0xc8,0xba,0xc8,0xb9,0xe5,0xd2,0xf7,0xe5,0x00};

//const unsigned char PY_mb_ran   []={"染燃然冉髯苒蚺"};
const unsigned char PY_mb_ran   []={0xc8,0xbe,0xc8,0xbc,0xc8,0xbb,0xc8,0xbd,0xf7,0xd7,0xdc,0xdb,0xf2,0xc5,0x00};

//const unsigned char PY_mb_rang  []={"让嚷瓤攘壤穰禳"};
const unsigned char PY_mb_rang  []={0xc8,0xc3,0xc8,0xc2,0xc8,0xbf,0xc8,0xc1,0xc8,0xc0,0xf0,0xa6,0xec,0xfc,0x00};

//const unsigned char PY_mb_rao   []={"饶绕扰荛桡娆"};
const unsigned char PY_mb_rao   []={0xc8,0xc4,0xc8,0xc6,0xc8,0xc5,0xdc,0xe9,0xe8,0xe3,0xe6,0xac,0x00};

//const unsigned char PY_mb_re    []={"热若惹喏"};
const unsigned char PY_mb_re    []={0xc8,0xc8,0xc8,0xf4,0xc8,0xc7,0xdf,0xf6,0x00};

//const unsigned char PY_mb_ren   []={"人任忍认刃仁韧妊纫壬饪轫仞荏葚衽稔"};
const unsigned char PY_mb_ren   []={0xc8,0xcb,0xc8,0xce,0xc8,0xcc,0xc8,0xcf,0xc8,0xd0,0xc8,0xca,0xc8,0xcd,0xc8,0xd1,0xc8,0xd2,0xc8,0xc9,0xe2,0xbf,0xe9,0xed,0xd8,0xf0,0xdc,0xf3,0xdd,0xd8,0xf1,0xc5,0xef,0xfe,0x00};

//const unsigned char PY_mb_reng  []={"扔仍"};
const unsigned char PY_mb_reng  []={0xc8,0xd3,0xc8,0xd4,0x00};

//const unsigned char PY_mb_ri    []={"日"};
const unsigned char PY_mb_ri    []={0xc8,0xd5,0x00};

//const unsigned char PY_mb_rong  []={"容绒融溶熔荣戎蓉冗茸榕狨嵘肜蝾"};
const unsigned char PY_mb_rong  []={0xc8,0xdd,0xc8,0xde,0xc8,0xda,0xc8,0xdc,0xc8,0xdb,0xc8,0xd9,0xc8,0xd6,0xc8,0xd8,0xc8,0xdf,0xc8,0xd7,0xe9,0xc5,0xe1,0xf5,0xe1,0xc9,0xeb,0xc0,0xf2,0xee,0x00};

//const unsigned char PY_mb_rou   []={"肉揉柔糅蹂鞣"};
const unsigned char PY_mb_rou   []={0xc8,0xe2,0xc8,0xe0,0xc8,0xe1,0xf4,0xdb,0xf5,0xe5,0xf7,0xb7,0x00};

//const unsigned char PY_mb_ru    []={"如入汝儒茹乳褥辱蠕孺蓐襦铷嚅缛濡薷颥溽洳"};
const unsigned char PY_mb_ru    []={0xc8,0xe7,0xc8,0xeb,0xc8,0xea,0xc8,0xe5,0xc8,0xe3,0xc8,0xe9,0xc8,0xec,0xc8,0xe8,0xc8,0xe4,0xc8,0xe6,0xdd,0xea,0xf1,0xe0,0xef,0xa8,0xe0,0xe9,0xe7,0xc8,0xe5,0xa6,0xde,0xb8,0xf2,0xac,0xe4,0xe1,0xe4,0xb2,0x00};

//const unsigned char PY_mb_ruan  []={"软阮朊"};
const unsigned char PY_mb_ruan  []={0xc8,0xed,0xc8,0xee,0xeb,0xc3,0x00};

//const unsigned char PY_mb_rui   []={"瑞蕊锐睿芮蚋枘蕤"};
const unsigned char PY_mb_rui   []={0xc8,0xf0,0xc8,0xef,0xc8,0xf1,0xee,0xa3,0xdc,0xc7,0xf2,0xb8,0xe8,0xc4,0xde,0xa8,0x00};

//const unsigned char PY_mb_run   []={"闰润"};
const unsigned char PY_mb_run   []={0xc8,0xf2,0xc8,0xf3,0x00};

//const unsigned char PY_mb_ruo   []={"若弱偌箬"};
const unsigned char PY_mb_ruo   []={0xc8,0xf4,0xc8,0xf5,0xd9,0xbc,0xf3,0xe8,0x00};

//const unsigned char PY_mb_sa    []={"撒洒萨挲仨卅飒脎"};
const unsigned char PY_mb_sa    []={0xc8,0xf6,0xc8,0xf7,0xc8,0xf8,0xea,0xfd,0xd8,0xed,0xd8,0xa6,0xec,0xaa,0xeb,0xdb,0x00};

//const unsigned char PY_mb_sai   []={"塞腮鳃思赛噻"};
const unsigned char PY_mb_sai   []={0xc8,0xfb,0xc8,0xf9,0xc8,0xfa,0xcb,0xbc,0xc8,0xfc,0xe0,0xe7,0x00};

//const unsigned char PY_mb_san   []={"三散伞叁馓糁毵霰"};
const unsigned char PY_mb_san   []={0xc8,0xfd,0xc9,0xa2,0xc9,0xa1,0xc8,0xfe,0xe2,0xcc,0xf4,0xd6,0xeb,0xa7,0xf6,0xb1,0x00};

//const unsigned char PY_mb_sang  []={"桑丧嗓颡磉搡"};
const unsigned char PY_mb_sang  []={0xc9,0xa3,0xc9,0xa5,0xc9,0xa4,0xf2,0xaa,0xed,0xdf,0xde,0xfa,0x00};

//const unsigned char PY_mb_sao   []={"扫嫂搔骚梢埽鳋臊缫瘙"};
const unsigned char PY_mb_sao   []={0xc9,0xa8,0xc9,0xa9,0xc9,0xa6,0xc9,0xa7,0xc9,0xd2,0xdc,0xa3,0xf6,0xfe,0xeb,0xfd,0xe7,0xd2,0xf0,0xfe,0x00};

//const unsigned char PY_mb_se    []={"色涩瑟塞啬铯穑"};
const unsigned char PY_mb_se    []={0xc9,0xab,0xc9,0xac,0xc9,0xaa,0xc8,0xfb,0xd8,0xc4,0xef,0xa4,0xf0,0xa3,0x00};

//const unsigned char PY_mb_sen   []={"森"};
const unsigned char PY_mb_sen   []={0xc9,0xad,0x00};

//const unsigned char PY_mb_seng  []={"僧"};
const unsigned char PY_mb_seng  []={0xc9,0xae,0x00};

//const unsigned char PY_mb_sha   []={"杀沙啥纱傻砂刹莎厦煞杉嗄唼鲨霎铩痧裟挲歃"};
const unsigned char PY_mb_sha   []={0xc9,0xb1,0xc9,0xb3,0xc9,0xb6,0xc9,0xb4,0xc9,0xb5,0xc9,0xb0,0xc9,0xb2,0xc9,0xaf,0xcf,0xc3,0xc9,0xb7,0xc9,0xbc,0xe0,0xc4,0xdf,0xfe,0xf6,0xe8,0xf6,0xae,0xef,0xa1,0xf0,0xf0,0xf4,0xc4,0xea,0xfd,0xec,0xa6,0x00};

//const unsigned char PY_mb_shai  []={"晒筛色酾"};
const unsigned char PY_mb_shai  []={0xc9,0xb9,0xc9,0xb8,0xc9,0xab,0xf5,0xa7,0x00};

//const unsigned char PY_mb_shan  []={"山闪衫善扇杉删煽单珊掺赡栅苫掸膳陕汕擅缮嬗蟮芟禅跚鄯潸鳝姗剡骟疝膻讪钐舢埏"};
const unsigned char PY_mb_shan  []={0xc9,0xbd,0xc9,0xc1,0xc9,0xc0,0xc9,0xc6,0xc9,0xc8,0xc9,0xbc,0xc9,0xbe,0xc9,0xbf,0xb5,0xa5,0xc9,0xba,0xb2,0xf4,0xc9,0xc4,0xd5,0xa4,0xc9,0xbb,0xb5,0xa7,0xc9,0xc5,0xc9,0xc2,0xc9,0xc7,0xc9,0xc3,0xc9,0xc9,0xe6,0xd3,0xf3,0xb5,0xdc,0xcf,0xec,0xf8,0xf5,0xc7,0xdb,0xb7,0xe4,0xfa,0xf7,0xad,0xe6,0xa9,0xd8,0xdf,0xe6,0xf3,0xf0,0xde,0xeb,0xfe,0xda,0xa8,0xee,0xcc,0xf4,0xae,0xdb,0xef,0x00};

//const unsigned char PY_mb_shang []={"上伤尚商赏晌墒汤裳熵觞绱殇垧"};
const unsigned char PY_mb_shang []={0xc9,0xcf,0xc9,0xcb,0xc9,0xd0,0xc9,0xcc,0xc9,0xcd,0xc9,0xce,0xc9,0xca,0xcc,0xc0,0xc9,0xd1,0xec,0xd8,0xf5,0xfc,0xe7,0xb4,0xe9,0xe4,0xdb,0xf0,0x00};

//const unsigned char PY_mb_shao  []={"少烧捎哨勺梢稍邵韶绍芍召鞘苕劭潲艄蛸筲"};
const unsigned char PY_mb_shao  []={0xc9,0xd9,0xc9,0xd5,0xc9,0xd3,0xc9,0xda,0xc9,0xd7,0xc9,0xd2,0xc9,0xd4,0xc9,0xdb,0xc9,0xd8,0xc9,0xdc,0xc9,0xd6,0xd5,0xd9,0xc7,0xca,0xdc,0xe6,0xdb,0xbf,0xe4,0xfb,0xf4,0xb9,0xf2,0xd9,0xf3,0xe2,0x00};

//const unsigned char PY_mb_she   []={"社射蛇设舌摄舍折涉赊赦慑奢歙厍畲猞麝滠佘"};
const unsigned char PY_mb_she   []={0xc9,0xe7,0xc9,0xe4,0xc9,0xdf,0xc9,0xe8,0xc9,0xe0,0xc9,0xe3,0xc9,0xe1,0xd5,0xdb,0xc9,0xe6,0xc9,0xde,0xc9,0xe2,0xc9,0xe5,0xc9,0xdd,0xec,0xa8,0xd8,0xc7,0xee,0xb4,0xe2,0xa6,0xf7,0xea,0xe4,0xdc,0xd9,0xdc,0x00};

//const unsigned char PY_mb_shen  []={"身伸深婶神甚渗肾审申沈绅呻参砷什娠慎葚糁莘诜谂矧椹渖蜃哂胂"};
const unsigned char PY_mb_shen  []={0xc9,0xed,0xc9,0xec,0xc9,0xee,0xc9,0xf4,0xc9,0xf1,0xc9,0xf5,0xc9,0xf8,0xc9,0xf6,0xc9,0xf3,0xc9,0xea,0xc9,0xf2,0xc9,0xf0,0xc9,0xeb,0xb2,0xce,0xc9,0xe9,0xca,0xb2,0xc9,0xef,0xc9,0xf7,0xdd,0xd8,0xf4,0xd6,0xdd,0xb7,0xda,0xb7,0xda,0xc5,0xef,0xf2,0xe9,0xa9,0xe4,0xc9,0xf2,0xd7,0xdf,0xd3,0xeb,0xcf,0x00};

//const unsigned char PY_mb_sheng []={"声省剩生升绳胜盛圣甥牲乘晟渑眚笙嵊"};
const unsigned char PY_mb_sheng []={0xc9,0xf9,0xca,0xa1,0xca,0xa3,0xc9,0xfa,0xc9,0xfd,0xc9,0xfe,0xca,0xa4,0xca,0xa2,0xca,0xa5,0xc9,0xfb,0xc9,0xfc,0xb3,0xcb,0xea,0xc9,0xe4,0xc5,0xed,0xf2,0xf3,0xcf,0xe1,0xd3,0x00};

//const unsigned char PY_mb_shi   []={"是使十时事室市石师试史式识虱矢拾屎驶始似嘘示士世柿匙拭誓逝势什殖峙嗜噬失适仕侍释饰氏狮食恃蚀视实施湿诗尸豕莳埘铈舐鲥鲺贳轼蓍筮炻谥弑酾螫"};
const unsigned char PY_mb_shi   []={0xca,0xc7,0xca,0xb9,0xca,0xae,0xca,0xb1,0xca,0xc2,0xca,0xd2,0xca,0xd0,0xca,0xaf,0xca,0xa6,0xca,0xd4,0xca,0xb7,0xca,0xbd,0xca,0xb6,0xca,0xad,0xca,0xb8,0xca,0xb0,0xca,0xba,0xca,0xbb,0xca,0xbc,0xcb,0xc6,0xd0,0xea,0xca,0xbe,0xca,0xbf,0xca,0xc0,0xca,0xc1,0xb3,0xd7,0xca,0xc3,0xca,0xc4,0xca,0xc5,0xca,0xc6,0xca,0xb2,0xd6,0xb3,0xd6,0xc5,0xca,0xc8,0xca,0xc9,0xca,0xa7,0xca,0xca,0xca,0xcb,0xca,0xcc,0xca,0xcd,0xca,0xce,0xca,0xcf,0xca,0xa8,0xca,0xb3,0xca,0xd1,0xca,0xb4,0xca,0xd3,0xca,0xb5,0xca,0xa9,0xca,0xaa,0xca,0xab,0xca,0xac,0xf5,0xb9,0xdd,0xaa,0xdb,0xf5,0xee,0xe6,0xf3,0xc2,0xf6,0xe5,0xf6,0xf5,0xea,0xdb,0xe9,0xf8,0xdd,0xe9,0xf3,0xdf,0xec,0xc2,0xda,0xd6,0xdf,0xb1,0xf5,0xa7,0xf3,0xa7,0x00};

//const unsigned char PY_mb_shou  []={"手受收首守瘦授兽售熟寿艏狩绶"};
const unsigned char PY_mb_shou  []={0xca,0xd6,0xca,0xdc,0xca,0xd5,0xca,0xd7,0xca,0xd8,0xca,0xdd,0xca,0xda,0xca,0xde,0xca,0xdb,0xca,0xec,0xca,0xd9,0xf4,0xbc,0xe1,0xf7,0xe7,0xb7,0x00};

//const unsigned char PY_mb_shu   []={"书树数熟输梳叔属束术述蜀黍鼠淑赎孰蔬疏戍竖墅庶薯漱恕枢暑殊抒曙署舒姝摅秫"};
const unsigned char PY_mb_shu   []={0xca,0xe9,0xca,0xf7,0xca,0xfd,0xca,0xec,0xca,0xe4,0xca,0xe1,0xca,0xe5,0xca,0xf4,0xca,0xf8,0xca,0xf5,0xca,0xf6,0xca,0xf1,0xca,0xf2,0xca,0xf3,0xca,0xe7,0xca,0xea,0xca,0xeb,0xca,0xdf,0xca,0xe8,0xca,0xf9,0xca,0xfa,0xca,0xfb,0xca,0xfc,0xca,0xed,0xca,0xfe,0xcb,0xa1,0xca,0xe0,0xca,0xee,0xca,0xe2,0xca,0xe3,0xca,0xef,0xca,0xf0,0xca,0xe6,0xe6,0xad,0xde,0xf3,0xef,0xf8,0x00};

//const unsigned char PY_mb_shua  []={"刷耍唰"};
const unsigned char PY_mb_shua  []={0xcb,0xa2,0xcb,0xa3,0xe0,0xa7,0x00};

//const unsigned char PY_mb_shuai []={"摔甩率帅衰蟀"};
const unsigned char PY_mb_shuai []={0xcb,0xa4,0xcb,0xa6,0xc2,0xca,0xcb,0xa7,0xcb,0xa5,0xf3,0xb0,0x00};

//const unsigned char PY_mb_shuan []={"栓拴闩涮"};
const unsigned char PY_mb_shuan []={0xcb,0xa8,0xcb,0xa9,0xe3,0xc5,0xe4,0xcc,0x00};

//const unsigned char PY_mb_shuang[]={"双霜爽泷孀"};
const unsigned char PY_mb_shuang[]={0xcb,0xab,0xcb,0xaa,0xcb,0xac,0xe3,0xf1,0xe6,0xd7,0x00};

//const unsigned char PY_mb_shui  []={"水谁睡税说"};
const unsigned char PY_mb_shui  []={0xcb,0xae,0xcb,0xad,0xcb,0xaf,0xcb,0xb0,0xcb,0xb5,0x00};

//const unsigned char PY_mb_shun  []={"顺吮瞬舜"};
const unsigned char PY_mb_shun  []={0xcb,0xb3,0xcb,0xb1,0xcb,0xb2,0xcb,0xb4,0x00};

//const unsigned char PY_mb_shuo  []={"说数硕烁朔搠妁槊蒴铄"};
const unsigned char PY_mb_shuo  []={0xcb,0xb5,0xca,0xfd,0xcb,0xb6,0xcb,0xb8,0xcb,0xb7,0xde,0xf7,0xe5,0xf9,0xe9,0xc3,0xdd,0xf4,0xee,0xe5,0x00};

//const unsigned char PY_mb_si    []={"四死丝撕似私嘶思寺司斯食伺厕肆饲嗣巳耜驷兕蛳厮汜锶泗笥咝鸶姒厶缌祀澌俟"};
const unsigned char PY_mb_si    []={0xcb,0xc4,0xcb,0xc0,0xcb,0xbf,0xcb,0xba,0xcb,0xc6,0xcb,0xbd,0xcb,0xbb,0xcb,0xbc,0xcb,0xc2,0xcb,0xbe,0xcb,0xb9,0xca,0xb3,0xcb,0xc5,0xb2,0xde,0xcb,0xc1,0xcb,0xc7,0xcb,0xc3,0xcb,0xc8,0xf1,0xea,0xe6,0xe1,0xd9,0xee,0xf2,0xcf,0xd8,0xcb,0xe3,0xe1,0xef,0xc8,0xe3,0xf4,0xf3,0xd3,0xdf,0xd0,0xf0,0xb8,0xe6,0xa6,0xdb,0xcc,0xe7,0xc1,0xec,0xeb,0xe4,0xf9,0xd9,0xb9,0x00};

//const unsigned char PY_mb_song  []={"送松耸宋颂诵怂讼竦菘淞悚嵩凇崧忪"};
const unsigned char PY_mb_song  []={0xcb,0xcd,0xcb,0xc9,0xcb,0xca,0xcb,0xce,0xcb,0xcc,0xcb,0xd0,0xcb,0xcb,0xcb,0xcf,0xf1,0xb5,0xdd,0xbf,0xe4,0xc1,0xe3,0xa4,0xe1,0xd4,0xda,0xa1,0xe1,0xc2,0xe2,0xec,0x00};

//const unsigned char PY_mb_sou   []={"艘搜擞嗽嗾嗖飕叟薮锼馊瞍溲螋擞"};
const unsigned char PY_mb_sou   []={0xcb,0xd2,0xcb,0xd1,0xcb,0xd3,0xcb,0xd4,0xe0,0xd5,0xe0,0xb2,0xec,0xac,0xdb,0xc5,0xde,0xb4,0xef,0xcb,0xe2,0xc8,0xee,0xa4,0xe4,0xd1,0xf2,0xf4,0xcb,0xd3,0x00};

//const unsigned char PY_mb_su    []={"素速诉塑宿俗苏肃粟酥缩溯僳愫簌觫稣夙嗉谡蔌涑"};
const unsigned char PY_mb_su    []={0xcb,0xd8,0xcb,0xd9,0xcb,0xdf,0xcb,0xdc,0xcb,0xde,0xcb,0xd7,0xcb,0xd5,0xcb,0xe0,0xcb,0xda,0xcb,0xd6,0xcb,0xf5,0xcb,0xdd,0xcb,0xdb,0xe3,0xba,0xf3,0xf9,0xf6,0xa2,0xf6,0xd5,0xd9,0xed,0xe0,0xbc,0xda,0xd5,0xdd,0xf8,0xe4,0xb3,0x00};

//const unsigned char PY_mb_suan  []={"酸算蒜狻"};
const unsigned char PY_mb_suan  []={0xcb,0xe1,0xcb,0xe3,0xcb,0xe2,0xe2,0xa1,0x00};

//const unsigned char PY_mb_sui   []={"岁随碎虽穗遂尿隋髓绥隧祟眭谇濉邃燧荽睢"};
const unsigned char PY_mb_sui   []={0xcb,0xea,0xcb,0xe6,0xcb,0xe9,0xcb,0xe4,0xcb,0xeb,0xcb,0xec,0xc4,0xf2,0xcb,0xe5,0xcb,0xe8,0xcb,0xe7,0xcb,0xed,0xcb,0xee,0xed,0xf5,0xda,0xc7,0xe5,0xa1,0xe5,0xe4,0xec,0xdd,0xdd,0xb4,0xee,0xa1,0x00};

//const unsigned char PY_mb_sun   []={"孙损笋榫荪飧狲隼"};
const unsigned char PY_mb_sun   []={0xcb,0xef,0xcb,0xf0,0xcb,0xf1,0xe9,0xbe,0xdd,0xa5,0xe2,0xb8,0xe1,0xf8,0xf6,0xc0,0x00};

//const unsigned char PY_mb_suo   []={"所缩锁琐索梭蓑莎唆挲睃嗍唢桫嗦娑羧"};
const unsigned char PY_mb_suo   []={0xcb,0xf9,0xcb,0xf5,0xcb,0xf8,0xcb,0xf6,0xcb,0xf7,0xcb,0xf3,0xcb,0xf2,0xc9,0xaf,0xcb,0xf4,0xea,0xfd,0xed,0xfc,0xe0,0xca,0xdf,0xef,0xe8,0xf8,0xe0,0xc2,0xe6,0xb6,0xf4,0xc8,0x00};

//const unsigned char PY_mb_ta    []={"他她它踏塔塌拓獭挞蹋溻趿鳎沓榻漯遢铊闼嗒"};
const unsigned char PY_mb_ta    []={0xcb,0xfb,0xcb,0xfd,0xcb,0xfc,0xcc,0xa4,0xcb,0xfe,0xcb,0xfa,0xcd,0xd8,0xcc,0xa1,0xcc,0xa2,0xcc,0xa3,0xe4,0xe2,0xf5,0xc1,0xf7,0xa3,0xed,0xb3,0xe9,0xbd,0xe4,0xf0,0xe5,0xdd,0xee,0xe8,0xe3,0xcb,0xe0,0xaa,0x00};

//const unsigned char PY_mb_tai   []={"太抬台态胎苔泰酞汰炱肽跆呔鲐钛薹邰骀"};
const unsigned char PY_mb_tai   []={0xcc,0xab,0xcc,0xa7,0xcc,0xa8,0xcc,0xac,0xcc,0xa5,0xcc,0xa6,0xcc,0xa9,0xcc,0xaa,0xcc,0xad,0xec,0xc6,0xeb,0xc4,0xf5,0xcc,0xdf,0xbe,0xf6,0xd8,0xee,0xd1,0xde,0xb7,0xdb,0xa2,0xe6,0xe6,0x00};

//const unsigned char PY_mb_tan   []={"谈叹探滩弹碳摊潭贪坛痰毯坦炭瘫谭坍檀袒郯昙忐钽锬澹镡覃"};
const unsigned char PY_mb_tan   []={0xcc,0xb8,0xcc,0xbe,0xcc,0xbd,0xcc,0xb2,0xb5,0xaf,0xcc,0xbc,0xcc,0xaf,0xcc,0xb6,0xcc,0xb0,0xcc,0xb3,0xcc,0xb5,0xcc,0xba,0xcc,0xb9,0xcc,0xbf,0xcc,0xb1,0xcc,0xb7,0xcc,0xae,0xcc,0xb4,0xcc,0xbb,0xdb,0xb0,0xea,0xbc,0xec,0xfe,0xee,0xe3,0xef,0xc4,0xe5,0xa3,0xef,0xe2,0xf1,0xfb,0x00};

//const unsigned char PY_mb_tang  []={"躺趟堂糖汤塘烫倘淌唐搪棠膛螳樘羰醣瑭镗傥饧溏耥帑铴螗"};
const unsigned char PY_mb_tang  []={0xcc,0xc9,0xcc,0xcb,0xcc,0xc3,0xcc,0xc7,0xcc,0xc0,0xcc,0xc1,0xcc,0xcc,0xcc,0xc8,0xcc,0xca,0xcc,0xc6,0xcc,0xc2,0xcc,0xc4,0xcc,0xc5,0xf3,0xab,0xe9,0xcc,0xf4,0xca,0xf5,0xb1,0xe8,0xa9,0xef,0xdb,0xd9,0xce,0xe2,0xbc,0xe4,0xe7,0xf1,0xed,0xe0,0xfb,0xef,0xa6,0xf3,0xa5,0x00};

//const unsigned char PY_mb_tao   []={"套掏逃桃讨淘涛滔陶绦萄鼗啕洮韬饕叨焘"};
const unsigned char PY_mb_tao   []={0xcc,0xd7,0xcc,0xcd,0xcc,0xd3,0xcc,0xd2,0xcc,0xd6,0xcc,0xd4,0xcc,0xce,0xcc,0xcf,0xcc,0xd5,0xcc,0xd0,0xcc,0xd1,0xd8,0xbb,0xdf,0xfb,0xe4,0xac,0xe8,0xba,0xf7,0xd2,0xdf,0xb6,0xec,0xe2,0x00};

//const unsigned char PY_mb_te    []={"特忑慝铽忒"};
const unsigned char PY_mb_te    []={0xcc,0xd8,0xec,0xfd,0xed,0xab,0xef,0xab,0xdf,0xaf,0x00};

//const unsigned char PY_mb_teng  []={"疼腾藤誊滕"};
const unsigned char PY_mb_teng  []={0xcc,0xdb,0xcc,0xda,0xcc,0xd9,0xcc,0xdc,0xeb,0xf8,0x00};

//const unsigned char PY_mb_ti    []={"提替体题踢蹄剃剔梯锑啼涕嚏惕屉醍鹈绨缇倜裼逖荑悌"};
const unsigned char PY_mb_ti    []={0xcc,0xe1,0xcc,0xe6,0xcc,0xe5,0xcc,0xe2,0xcc,0xdf,0xcc,0xe3,0xcc,0xea,0xcc,0xde,0xcc,0xdd,0xcc,0xe0,0xcc,0xe4,0xcc,0xe9,0xcc,0xe7,0xcc,0xe8,0xcc,0xeb,0xf5,0xae,0xf0,0xc3,0xe7,0xb0,0xe7,0xbe,0xd9,0xc3,0xf1,0xd3,0xe5,0xd1,0xdc,0xe8,0xe3,0xa9,0x00};

//const unsigned char PY_mb_tian  []={"天田添填甜舔恬腆佃掭钿阗忝殄畋"};
const unsigned char PY_mb_tian  []={0xcc,0xec,0xcc,0xef,0xcc,0xed,0xcc,0xee,0xcc,0xf0,0xcc,0xf2,0xcc,0xf1,0xcc,0xf3,0xb5,0xe8,0xde,0xdd,0xee,0xe4,0xe3,0xd9,0xe3,0xc3,0xe9,0xe5,0xee,0xb1,0x00};

//const unsigned char PY_mb_tiao  []={"条跳挑调迢眺龆笤祧蜩髫佻窕鲦苕粜"};
const unsigned char PY_mb_tiao  []={0xcc,0xf5,0xcc,0xf8,0xcc,0xf4,0xb5,0xf7,0xcc,0xf6,0xcc,0xf7,0xf6,0xb6,0xf3,0xd4,0xec,0xf6,0xf2,0xe8,0xf7,0xd8,0xd9,0xac,0xf1,0xbb,0xf6,0xe6,0xdc,0xe6,0xf4,0xd0,0x00};

//const unsigned char PY_mb_tie   []={"铁贴帖萜餮"};
const unsigned char PY_mb_tie   []={0xcc,0xfa,0xcc,0xf9,0xcc,0xfb,0xdd,0xc6,0xf7,0xd1,0x00};

//const unsigned char PY_mb_ting  []={"听停挺厅亭艇庭廷烃汀莛葶婷梃蜓霆町铤"};
const unsigned char PY_mb_ting  []={0xcc,0xfd,0xcd,0xa3,0xcd,0xa6,0xcc,0xfc,0xcd,0xa4,0xcd,0xa7,0xcd,0xa5,0xcd,0xa2,0xcc,0xfe,0xcd,0xa1,0xdc,0xf0,0xdd,0xe3,0xe6,0xc3,0xe8,0xe8,0xf2,0xd1,0xf6,0xaa,0xee,0xae,0xee,0xfa,0x00};

//const unsigned char PY_mb_tong  []={"同通痛铜桶筒捅统童彤桐瞳恫侗酮潼茼仝砼峒恸佟嗵垌"};
const unsigned char PY_mb_tong  []={0xcd,0xac,0xcd,0xa8,0xcd,0xb4,0xcd,0xad,0xcd,0xb0,0xcd,0xb2,0xcd,0xb1,0xcd,0xb3,0xcd,0xaf,0xcd,0xae,0xcd,0xa9,0xcd,0xab,0xb6,0xb2,0xb6,0xb1,0xcd,0xaa,0xe4,0xfc,0xdc,0xed,0xd9,0xda,0xed,0xc5,0xe1,0xbc,0xe2,0xfa,0xd9,0xa1,0xe0,0xcc,0xdb,0xed,0x00};

//const unsigned char PY_mb_tou   []={"头偷透投钭骰"};
const unsigned char PY_mb_tou   []={0xcd,0xb7,0xcd,0xb5,0xcd,0xb8,0xcd,0xb6,0xee,0xd7,0xf7,0xbb,0x00};

//const unsigned char PY_mb_tu    []={"土图兔涂吐秃突徒凸途屠堍荼菟钍酴"};
const unsigned char PY_mb_tu    []={0xcd,0xc1,0xcd,0xbc,0xcd,0xc3,0xcd,0xbf,0xcd,0xc2,0xcd,0xba,0xcd,0xbb,0xcd,0xbd,0xcd,0xb9,0xcd,0xbe,0xcd,0xc0,0xdc,0xa2,0xdd,0xb1,0xdd,0xcb,0xee,0xca,0xf5,0xa9,0x00};

//const unsigned char PY_mb_tuan  []={"团湍疃抟彖"};
const unsigned char PY_mb_tuan  []={0xcd,0xc5,0xcd,0xc4,0xee,0xb6,0xde,0xd2,0xe5,0xe8,0x00};

//const unsigned char PY_mb_tui   []={"腿推退褪颓蜕煺忒"};
const unsigned char PY_mb_tui   []={0xcd,0xc8,0xcd,0xc6,0xcd,0xcb,0xcd,0xca,0xcd,0xc7,0xcd,0xc9,0xec,0xd5,0xdf,0xaf,0x00};

//const unsigned char PY_mb_tun   []={"吞屯褪臀囤氽饨暾豚"};
const unsigned char PY_mb_tun   []={0xcd,0xcc,0xcd,0xcd,0xcd,0xca,0xcd,0xce,0xb6,0xda,0xd9,0xdb,0xe2,0xbd,0xea,0xd5,0xeb,0xe0,0x00};

//const unsigned char PY_mb_tuo   []={"拖脱托妥驮拓驼椭唾鸵陀魄乇佗坨庹沱柝柁橐跎箨酡砣鼍"};
const unsigned char PY_mb_tuo   []={0xcd,0xcf,0xcd,0xd1,0xcd,0xd0,0xcd,0xd7,0xcd,0xd4,0xcd,0xd8,0xcd,0xd5,0xcd,0xd6,0xcd,0xd9,0xcd,0xd2,0xcd,0xd3,0xc6,0xc7,0xd8,0xb1,0xd9,0xa2,0xdb,0xe7,0xe2,0xd5,0xe3,0xfb,0xe8,0xd8,0xe8,0xde,0xe9,0xd2,0xf5,0xc9,0xf3,0xea,0xf5,0xa2,0xed,0xc8,0xf6,0xbe,0x00};

//const unsigned char PY_mb_wa    []={"挖瓦蛙哇娃洼凹袜佤娲腽"};
const unsigned char PY_mb_wa    []={0xcd,0xda,0xcd,0xdf,0xcd,0xdc,0xcd,0xdb,0xcd,0xde,0xcd,0xdd,0xb0,0xbc,0xcd,0xe0,0xd8,0xf4,0xe6,0xb4,0xeb,0xf0,0x00};

//const unsigned char PY_mb_wai   []={"外歪崴"};
const unsigned char PY_mb_wai   []={0xcd,0xe2,0xcd,0xe1,0xe1,0xcb,0x00};

//const unsigned char PY_mb_wan   []={"完万晚碗玩弯挽湾丸腕宛婉烷顽豌惋娩皖蔓莞脘蜿绾芄琬纨剜畹菀"};
const unsigned char PY_mb_wan   []={0xcd,0xea,0xcd,0xf2,0xcd,0xed,0xcd,0xeb,0xcd,0xe6,0xcd,0xe4,0xcd,0xec,0xcd,0xe5,0xcd,0xe8,0xcd,0xf3,0xcd,0xf0,0xcd,0xf1,0xcd,0xe9,0xcd,0xe7,0xcd,0xe3,0xcd,0xef,0xc3,0xe4,0xcd,0xee,0xc2,0xfb,0xdd,0xb8,0xeb,0xe4,0xf2,0xea,0xe7,0xba,0xdc,0xb9,0xe7,0xfe,0xe6,0xfd,0xd8,0xe0,0xee,0xb5,0xdd,0xd2,0x00};

//const unsigned char PY_mb_wang  []={"望忘王往网亡枉旺汪妄芒罔惘辋魍"};
const unsigned char PY_mb_wang  []={0xcd,0xfb,0xcd,0xfc,0xcd,0xf5,0xcd,0xf9,0xcd,0xf8,0xcd,0xf6,0xcd,0xf7,0xcd,0xfa,0xcd,0xf4,0xcd,0xfd,0xc3,0xa2,0xd8,0xe8,0xe3,0xaf,0xe9,0xfe,0xf7,0xcd,0x00};

//const unsigned char PY_mb_wei   []={"为位未围喂胃微味尾伪威伟卫危违委魏唯维畏惟韦巍蔚谓尉潍纬慰桅萎苇渭遗葳帏艉鲔娓逶闱隈沩玮涠帷崴隗诿洧偎猥猬嵬軎韪炜煨圩薇痿"};
const unsigned char PY_mb_wei   []={0xce,0xaa,0xce,0xbb,0xce,0xb4,0xce,0xa7,0xce,0xb9,0xce,0xb8,0xce,0xa2,0xce,0xb6,0xce,0xb2,0xce,0xb1,0xcd,0xfe,0xce,0xb0,0xce,0xc0,0xce,0xa3,0xce,0xa5,0xce,0xaf,0xce,0xba,0xce,0xa8,0xce,0xac,0xce,0xb7,0xce,0xa9,0xce,0xa4,0xce,0xa1,0xce,0xb5,0xce,0xbd,0xce,0xbe,0xce,0xab,0xce,0xb3,0xce,0xbf,0xce,0xa6,0xce,0xae,0xce,0xad,0xce,0xbc,0xd2,0xc5,0xdd,0xda,0xe0,0xf8,0xf4,0xba,0xf6,0xdb,0xe6,0xb8,0xe5,0xd4,0xe3,0xc7,0xda,0xf1,0xe3,0xed,0xe7,0xe2,0xe4,0xb6,0xe1,0xa1,0xe1,0xcb,0xda,0xf3,0xda,0xc3,0xe4,0xa2,0xd9,0xcb,0xe2,0xab,0xe2,0xac,0xe1,0xcd,0xea,0xa6,0xe8,0xb8,0xec,0xbf,0xec,0xd0,0xdb,0xd7,0xde,0xb1,0xf0,0xf4,0x00};

//const unsigned char PY_mb_wen   []={"问文闻稳温吻蚊纹瘟紊汶阌刎雯璺"};
const unsigned char PY_mb_wen   []={0xce,0xca,0xce,0xc4,0xce,0xc5,0xce,0xc8,0xce,0xc2,0xce,0xc7,0xce,0xc3,0xce,0xc6,0xce,0xc1,0xce,0xc9,0xe3,0xeb,0xe3,0xd3,0xd8,0xd8,0xf6,0xa9,0xe8,0xb7,0x00};

//const unsigned char PY_mb_weng  []={"翁嗡瓮蓊蕹"};
const unsigned char PY_mb_weng  []={0xce,0xcc,0xce,0xcb,0xce,0xcd,0xdd,0xee,0xde,0xb3,0x00};

//const unsigned char PY_mb_wo    []={"我握窝卧挝沃蜗涡斡倭幄龌肟莴喔渥硪"};
const unsigned char PY_mb_wo    []={0xce,0xd2,0xce,0xd5,0xce,0xd1,0xce,0xd4,0xce,0xce,0xce,0xd6,0xce,0xcf,0xce,0xd0,0xce,0xd3,0xd9,0xc1,0xe1,0xa2,0xf6,0xbb,0xeb,0xbf,0xdd,0xab,0xe0,0xb8,0xe4,0xd7,0xed,0xd2,0x00};

//const unsigned char PY_mb_wu    []={"无五屋物舞雾误捂污悟勿钨武戊务呜伍吴午吾侮乌毋恶诬芜巫晤梧坞妩蜈牾寤兀怃阢邬忤骛於鋈仵杌鹜婺迕痦芴焐唔庑鹉鼯浯圬"};
const unsigned char PY_mb_wu    []={0xce,0xde,0xce,0xe5,0xce,0xdd,0xce,0xef,0xce,0xe8,0xce,0xed,0xce,0xf3,0xce,0xe6,0xce,0xdb,0xce,0xf2,0xce,0xf0,0xce,0xd9,0xce,0xe4,0xce,0xec,0xce,0xf1,0xce,0xd8,0xce,0xe9,0xce,0xe2,0xce,0xe7,0xce,0xe1,0xce,0xea,0xce,0xda,0xce,0xe3,0xb6,0xf1,0xce,0xdc,0xce,0xdf,0xce,0xd7,0xce,0xee,0xce,0xe0,0xce,0xeb,0xe5,0xfc,0xf2,0xda,0xea,0xf5,0xe5,0xbb,0xd8,0xa3,0xe2,0xe4,0xda,0xe3,0xda,0xf9,0xe2,0xe8,0xe6,0xf0,0xec,0xb6,0xf6,0xc8,0xd8,0xf5,0xe8,0xbb,0xf0,0xcd,0xe6,0xc4,0xe5,0xc3,0xf0,0xed,0xdc,0xcc,0xec,0xc9,0xdf,0xed,0xe2,0xd0,0xf0,0xc4,0xf7,0xf9,0xe4,0xb4,0xdb,0xd8,0x00};

//const unsigned char PY_mb_xi    []={"西洗细吸戏系喜席稀溪熄锡膝息袭惜习嘻夕悉矽熙希檄牺晰昔媳硒铣烯腊析隙栖汐犀蜥奚浠葸饩屣玺嬉禊兮翕穸禧僖淅蓰舾蹊醯欷皙蟋羲茜徙隰郗唏曦螅歙樨阋粞熹觋菥鼷裼舄"};
const unsigned char PY_mb_xi    []={0xce,0xf7,0xcf,0xb4,0xcf,0xb8,0xce,0xfc,0xcf,0xb7,0xcf,0xb5,0xcf,0xb2,0xcf,0xaf,0xcf,0xa1,0xcf,0xaa,0xcf,0xa8,0xce,0xfd,0xcf,0xa5,0xcf,0xa2,0xcf,0xae,0xcf,0xa7,0xcf,0xb0,0xce,0xfb,0xcf,0xa6,0xcf,0xa4,0xce,0xf9,0xce,0xf5,0xcf,0xa3,0xcf,0xad,0xce,0xfe,0xce,0xfa,0xce,0xf4,0xcf,0xb1,0xce,0xf8,0xcf,0xb3,0xcf,0xa9,0xc0,0xb0,0xce,0xf6,0xcf,0xb6,0xc6,0xdc,0xcf,0xab,0xcf,0xac,0xf2,0xe1,0xde,0xc9,0xe4,0xbb,0xdd,0xdf,0xe2,0xbe,0xe5,0xef,0xe7,0xf4,0xe6,0xd2,0xec,0xf9,0xd9,0xe2,0xf4,0xe2,0xf1,0xb6,0xec,0xfb,0xd9,0xd2,0xe4,0xc0,0xdd,0xfb,0xf4,0xb8,0xf5,0xe8,0xf5,0xb5,0xec,0xa4,0xf0,0xaa,0xf3,0xac,0xf4,0xcb,0xdc,0xe7,0xe1,0xe3,0xda,0xf4,0xdb,0xad,0xdf,0xf1,0xea,0xd8,0xf3,0xa3,0xec,0xa8,0xe9,0xd8,0xe3,0xd2,0xf4,0xd1,0xec,0xe4,0xea,0xea,0xdd,0xbe,0xf7,0xfb,0xf1,0xd3,0xf4,0xaa,0x00};

//const unsigned char PY_mb_xia   []={"下吓夏峡虾瞎霞狭匣侠辖厦暇唬狎遐瑕柙硖罅黠呷"};
const unsigned char PY_mb_xia   []={0xcf,0xc2,0xcf,0xc5,0xcf,0xc4,0xcf,0xbf,0xcf,0xba,0xcf,0xb9,0xcf,0xbc,0xcf,0xc1,0xcf,0xbb,0xcf,0xc0,0xcf,0xbd,0xcf,0xc3,0xcf,0xbe,0xbb,0xa3,0xe1,0xf2,0xe5,0xda,0xe8,0xa6,0xe8,0xd4,0xed,0xcc,0xf3,0xc1,0xf7,0xef,0xdf,0xc8,0x00};

//const unsigned char PY_mb_xian  []={"先线县现显掀闲献嫌陷险鲜弦衔馅限咸锨仙腺贤纤宪舷涎羡铣见苋藓岘痫莶籼娴蚬猃祆冼燹跣跹酰暹氙鹇筅霰"};
const unsigned char PY_mb_xian  []={0xcf,0xc8,0xcf,0xdf,0xcf,0xd8,0xcf,0xd6,0xcf,0xd4,0xcf,0xc6,0xcf,0xd0,0xcf,0xd7,0xcf,0xd3,0xcf,0xdd,0xcf,0xd5,0xcf,0xca,0xcf,0xd2,0xcf,0xce,0xcf,0xda,0xcf,0xde,0xcf,0xcc,0xcf,0xc7,0xcf,0xc9,0xcf,0xd9,0xcf,0xcd,0xcf,0xcb,0xcf,0xdc,0xcf,0xcf,0xcf,0xd1,0xcf,0xdb,0xcf,0xb3,0xbc,0xfb,0xdc,0xc8,0xde,0xba,0xe1,0xad,0xf0,0xef,0xdd,0xb2,0xf4,0xcc,0xe6,0xb5,0xf2,0xb9,0xe1,0xfd,0xec,0xec,0xd9,0xfe,0xec,0xde,0xf5,0xd0,0xf5,0xd1,0xf5,0xa3,0xe5,0xdf,0xeb,0xaf,0xf0,0xc2,0xf3,0xda,0xf6,0xb1,0x00};

//const unsigned char PY_mb_xiang []={"想向象项响香乡相像箱巷享镶厢降翔祥橡详湘襄芗葙饷庠骧缃蟓鲞飨"};
const unsigned char PY_mb_xiang []={0xcf,0xeb,0xcf,0xf2,0xcf,0xf3,0xcf,0xee,0xcf,0xec,0xcf,0xe3,0xcf,0xe7,0xcf,0xe0,0xcf,0xf1,0xcf,0xe4,0xcf,0xef,0xcf,0xed,0xcf,0xe2,0xcf,0xe1,0xbd,0xb5,0xcf,0xe8,0xcf,0xe9,0xcf,0xf0,0xcf,0xea,0xcf,0xe6,0xcf,0xe5,0xdc,0xbc,0xdd,0xd9,0xe2,0xc3,0xe2,0xd4,0xe6,0xf8,0xe7,0xbd,0xf3,0xad,0xf6,0xdf,0xf7,0xcf,0x00};

//const unsigned char PY_mb_xiao  []={"小笑消削销萧效宵晓肖孝硝啸霄哮嚣校骁哓潇逍枭绡淆崤箫枵筱魈蛸"};
const unsigned char PY_mb_xiao  []={0xd0,0xa1,0xd0,0xa6,0xcf,0xfb,0xcf,0xf7,0xcf,0xfa,0xcf,0xf4,0xd0,0xa7,0xcf,0xfc,0xcf,0xfe,0xd0,0xa4,0xd0,0xa2,0xcf,0xf5,0xd0,0xa5,0xcf,0xf6,0xcf,0xf8,0xcf,0xf9,0xd0,0xa3,0xe6,0xe7,0xdf,0xd8,0xe4,0xec,0xe5,0xd0,0xe8,0xc9,0xe7,0xaf,0xcf,0xfd,0xe1,0xc5,0xf3,0xef,0xe8,0xd5,0xf3,0xe3,0xf7,0xcc,0xf2,0xd9,0x00};

//const unsigned char PY_mb_xie   []={"写些鞋歇斜血谢卸挟屑蟹泻懈泄楔邪协械谐蝎携胁解契叶绁颉缬獬榭廨撷偕瀣渫亵榍邂薤躞燮勰"};
const unsigned char PY_mb_xie   []={0xd0,0xb4,0xd0,0xa9,0xd0,0xac,0xd0,0xaa,0xd0,0xb1,0xd1,0xaa,0xd0,0xbb,0xd0,0xb6,0xd0,0xae,0xd0,0xbc,0xd0,0xb7,0xd0,0xba,0xd0,0xb8,0xd0,0xb9,0xd0,0xa8,0xd0,0xb0,0xd0,0xad,0xd0,0xb5,0xd0,0xb3,0xd0,0xab,0xd0,0xaf,0xd0,0xb2,0xbd,0xe2,0xc6,0xf5,0xd2,0xb6,0xe7,0xa5,0xf2,0xa1,0xe7,0xd3,0xe2,0xb3,0xe9,0xbf,0xe2,0xdd,0xdf,0xa2,0xd9,0xc9,0xe5,0xac,0xe4,0xcd,0xd9,0xf4,0xe9,0xc7,0xe5,0xe2,0xde,0xaf,0xf5,0xf3,0xdb,0xc6,0xdb,0xc4,0x00};

//const unsigned char PY_mb_xin   []={"新心欣信芯薪锌辛寻衅忻歆囟莘馨鑫昕镡"};
const unsigned char PY_mb_xin   []={0xd0,0xc2,0xd0,0xc4,0xd0,0xc0,0xd0,0xc5,0xd0,0xbe,0xd0,0xbd,0xd0,0xbf,0xd0,0xc1,0xd1,0xb0,0xd0,0xc6,0xd0,0xc3,0xec,0xa7,0xd8,0xb6,0xdd,0xb7,0xdc,0xb0,0xf6,0xce,0xea,0xbf,0xef,0xe2,0x00};

//const unsigned char PY_mb_xing  []={"性行型形星醒姓腥刑杏兴幸邢猩惺省硎悻荥陉擤荇"};
const unsigned char PY_mb_xing  []={0xd0,0xd4,0xd0,0xd0,0xd0,0xcd,0xd0,0xce,0xd0,0xc7,0xd0,0xd1,0xd0,0xd5,0xd0,0xc8,0xd0,0xcc,0xd0,0xd3,0xd0,0xcb,0xd0,0xd2,0xd0,0xcf,0xd0,0xc9,0xd0,0xca,0xca,0xa1,0xed,0xca,0xe3,0xac,0xdc,0xfe,0xda,0xea,0xdf,0xa9,0xdc,0xf4,0x00};

//const unsigned char PY_mb_xiong []={"胸雄凶兄熊汹匈芎"};
const unsigned char PY_mb_xiong []={0xd0,0xd8,0xd0,0xdb,0xd0,0xd7,0xd0,0xd6,0xd0,0xdc,0xd0,0xda,0xd0,0xd9,0xdc,0xba,0x00};

//const unsigned char PY_mb_xiu   []={"修锈绣休羞宿嗅袖秀朽臭咻岫馐庥溴鸺貅髹"};
const unsigned char PY_mb_xiu   []={0xd0,0xde,0xd0,0xe2,0xd0,0xe5,0xd0,0xdd,0xd0,0xdf,0xcb,0xde,0xd0,0xe1,0xd0,0xe4,0xd0,0xe3,0xd0,0xe0,0xb3,0xf4,0xdf,0xdd,0xe1,0xb6,0xe2,0xca,0xe2,0xd3,0xe4,0xe5,0xf0,0xbc,0xf5,0xf7,0xf7,0xdb,0x00};

//const unsigned char PY_mb_xu    []={"许须需虚嘘蓄续序叙畜絮婿戌徐旭绪吁酗恤墟糈勖栩浒蓿顼圩洫胥醑诩溆煦盱砉"};
const unsigned char PY_mb_xu    []={0xd0,0xed,0xd0,0xeb,0xd0,0xe8,0xd0,0xe9,0xd0,0xea,0xd0,0xee,0xd0,0xf8,0xd0,0xf2,0xd0,0xf0,0xd0,0xf3,0xd0,0xf5,0xd0,0xf6,0xd0,0xe7,0xd0,0xec,0xd0,0xf1,0xd0,0xf7,0xd3,0xf5,0xd0,0xef,0xd0,0xf4,0xd0,0xe6,0xf4,0xda,0xdb,0xc3,0xe8,0xf2,0xe4,0xb0,0xde,0xa3,0xe7,0xef,0xdb,0xd7,0xe4,0xaa,0xf1,0xe3,0xf5,0xaf,0xda,0xbc,0xe4,0xd3,0xec,0xe3,0xed,0xec,0xed,0xb9,0x00};

//const unsigned char PY_mb_xuan  []={"选悬旋玄宣喧轩绚眩癣券儇炫谖萱揎泫渲漩璇楦暄煊碹铉镟痃"};
const unsigned char PY_mb_xuan  []={0xd1,0xa1,0xd0,0xfc,0xd0,0xfd,0xd0,0xfe,0xd0,0xfb,0xd0,0xfa,0xd0,0xf9,0xd1,0xa4,0xd1,0xa3,0xd1,0xa2,0xc8,0xaf,0xd9,0xd8,0xec,0xc5,0xda,0xce,0xdd,0xe6,0xde,0xef,0xe3,0xf9,0xe4,0xd6,0xe4,0xf6,0xe8,0xaf,0xe9,0xb8,0xea,0xd1,0xec,0xd3,0xed,0xdb,0xee,0xe7,0xef,0xe0,0xf0,0xe7,0x00};

//const unsigned char PY_mb_xue   []={"学雪血靴穴削薛踅噱鳕泶"};
const unsigned char PY_mb_xue   []={0xd1,0xa7,0xd1,0xa9,0xd1,0xaa,0xd1,0xa5,0xd1,0xa8,0xcf,0xf7,0xd1,0xa6,0xf5,0xbd,0xe0,0xe5,0xf7,0xa8,0xed,0xb4,0x00};

//const unsigned char PY_mb_xun   []={"寻讯熏训循殉旬巡迅驯汛逊勋荤询浚巽埙荀蕈薰峋徇獯恂洵浔曛醺鲟郇窨"};
const unsigned char PY_mb_xun   []={0xd1,0xb0,0xd1,0xb6,0xd1,0xac,0xd1,0xb5,0xd1,0xad,0xd1,0xb3,0xd1,0xae,0xd1,0xb2,0xd1,0xb8,0xd1,0xb1,0xd1,0xb4,0xd1,0xb7,0xd1,0xab,0xbb,0xe7,0xd1,0xaf,0xbf,0xa3,0xd9,0xe3,0xdb,0xf7,0xdc,0xf7,0xde,0xa6,0xde,0xb9,0xe1,0xbe,0xe1,0xdf,0xe2,0xb4,0xe2,0xfe,0xe4,0xad,0xe4,0xb1,0xea,0xd6,0xf5,0xb8,0xf6,0xe0,0xdb,0xa8,0xf1,0xbf,0x00};

//const unsigned char PY_mb_ya    []={"呀压牙押芽鸭轧崖哑亚涯丫雅衙鸦讶蚜伢垭揠岈迓娅琊桠氩砑睚痖疋"};
const unsigned char PY_mb_ya    []={0xd1,0xbd,0xd1,0xb9,0xd1,0xc0,0xd1,0xba,0xd1,0xbf,0xd1,0xbc,0xd4,0xfe,0xd1,0xc2,0xd1,0xc6,0xd1,0xc7,0xd1,0xc4,0xd1,0xbe,0xd1,0xc5,0xd1,0xc3,0xd1,0xbb,0xd1,0xc8,0xd1,0xc1,0xd8,0xf3,0xdb,0xeb,0xde,0xeb,0xe1,0xac,0xe5,0xc2,0xe6,0xab,0xe7,0xf0,0xe8,0xe2,0xeb,0xb2,0xed,0xbc,0xed,0xfd,0xf0,0xe9,0xf1,0xe2,0x00};

//const unsigned char PY_mb_yan   []={"眼烟沿盐言演严咽淹炎掩厌宴岩研延堰验艳阉砚雁唁彦焰蜒衍谚燕颜阎焉奄厣菸魇琰滟焱筵赝兖恹檐湮谳偃胭晏闫俨郾鄢妍崦嫣罨酽餍鼹铅殷阽芫阏腌剡"};
const unsigned char PY_mb_yan   []={0xd1,0xdb,0xd1,0xcc,0xd1,0xd8,0xd1,0xce,0xd1,0xd4,0xd1,0xdd,0xd1,0xcf,0xd1,0xca,0xd1,0xcd,0xd1,0xd7,0xd1,0xda,0xd1,0xe1,0xd1,0xe7,0xd1,0xd2,0xd1,0xd0,0xd1,0xd3,0xd1,0xdf,0xd1,0xe9,0xd1,0xde,0xd1,0xcb,0xd1,0xe2,0xd1,0xe3,0xd1,0xe4,0xd1,0xe5,0xd1,0xe6,0xd1,0xd1,0xd1,0xdc,0xd1,0xe8,0xd1,0xe0,0xd1,0xd5,0xd1,0xd6,0xd1,0xc9,0xd1,0xd9,0xd8,0xc9,0xdd,0xce,0xf7,0xca,0xe7,0xfc,0xe4,0xd9,0xec,0xcd,0xf3,0xdb,0xd8,0xcd,0xd9,0xf0,0xe2,0xfb,0xe9,0xdc,0xe4,0xce,0xda,0xdd,0xd9,0xc8,0xeb,0xd9,0xea,0xcc,0xe3,0xc6,0xd9,0xb2,0xdb,0xb1,0xdb,0xb3,0xe5,0xfb,0xe1,0xc3,0xe6,0xcc,0xee,0xbb,0xf5,0xa6,0xf7,0xd0,0xf7,0xfa,0xc7,0xa6,0xd2,0xf3,0xda,0xe7,0xdc,0xbe,0xe3,0xd5,0xeb,0xe7,0xd8,0xdf,0x00};

//const unsigned char PY_mb_yang  []={"样养羊洋仰扬秧氧痒杨漾阳殃央鸯佯疡炀恙徉鞅泱蛘烊怏"};
const unsigned char PY_mb_yang  []={0xd1,0xf9,0xd1,0xf8,0xd1,0xf2,0xd1,0xf3,0xd1,0xf6,0xd1,0xef,0xd1,0xed,0xd1,0xf5,0xd1,0xf7,0xd1,0xee,0xd1,0xfa,0xd1,0xf4,0xd1,0xea,0xd1,0xeb,0xd1,0xec,0xd1,0xf0,0xd1,0xf1,0xec,0xbe,0xed,0xa6,0xe1,0xe0,0xf7,0xb1,0xe3,0xf3,0xf2,0xd5,0xec,0xc8,0xe2,0xf3,0x00};

//const unsigned char PY_mb_yao   []={"要摇药咬腰窑舀邀妖谣遥姚瑶耀尧钥侥夭爻吆崾徭幺珧杳轺曜肴鹞窈鳐疟陶约铫"};
const unsigned char PY_mb_yao   []={0xd2,0xaa,0xd2,0xa1,0xd2,0xa9,0xd2,0xa7,0xd1,0xfc,0xd2,0xa4,0xd2,0xa8,0xd1,0xfb,0xd1,0xfd,0xd2,0xa5,0xd2,0xa3,0xd2,0xa6,0xd1,0xfe,0xd2,0xab,0xd2,0xa2,0xd4,0xbf,0xbd,0xc4,0xd8,0xb2,0xd8,0xb3,0xdf,0xba,0xe1,0xca,0xe1,0xe6,0xe7,0xdb,0xe7,0xf2,0xe8,0xc3,0xe9,0xf7,0xea,0xd7,0xeb,0xc8,0xf0,0xce,0xf1,0xba,0xf7,0xa5,0xc5,0xb1,0xcc,0xd5,0xd4,0xbc,0xef,0xa2,0x00};

//const unsigned char PY_mb_ye    []={"也夜业野叶爷页液掖腋冶噎耶咽曳椰邪谒邺晔烨揶铘靥"};
const unsigned char PY_mb_ye    []={0xd2,0xb2,0xd2,0xb9,0xd2,0xb5,0xd2,0xb0,0xd2,0xb6,0xd2,0xaf,0xd2,0xb3,0xd2,0xba,0xd2,0xb4,0xd2,0xb8,0xd2,0xb1,0xd2,0xad,0xd2,0xae,0xd1,0xca,0xd2,0xb7,0xd2,0xac,0xd0,0xb0,0xda,0xcb,0xda,0xfe,0xea,0xca,0xec,0xc7,0xde,0xde,0xee,0xf4,0xd8,0xcc,0x00};

//const unsigned char PY_mb_yi    []={"一以已亿衣移依易医乙仪亦椅益倚姨翼译伊蛇遗食艾胰疑沂宜异彝壹蚁谊揖铱矣翌艺抑绎邑蛾屹尾役臆逸肄疫颐裔意毅忆义夷溢诣议怿痍镒癔怡驿旖熠酏翊欹峄圯殪嗌咦懿噫劓诒饴漪佚咿瘗猗眙羿弈苡荑仡佾贻钇缢迤刈悒黟翳弋奕蜴埸挹嶷薏呓轶镱"};
const unsigned char PY_mb_yi    []={0xd2,0xbb,0xd2,0xd4,0xd2,0xd1,0xd2,0xda,0xd2,0xc2,0xd2,0xc6,0xd2,0xc0,0xd2,0xd7,0xd2,0xbd,0xd2,0xd2,0xd2,0xc7,0xd2,0xe0,0xd2,0xce,0xd2,0xe6,0xd2,0xd0,0xd2,0xcc,0xd2,0xed,0xd2,0xeb,0xd2,0xc1,0xc9,0xdf,0xd2,0xc5,0xca,0xb3,0xb0,0xac,0xd2,0xc8,0xd2,0xc9,0xd2,0xca,0xd2,0xcb,0xd2,0xec,0xd2,0xcd,0xd2,0xbc,0xd2,0xcf,0xd2,0xea,0xd2,0xbe,0xd2,0xbf,0xd2,0xd3,0xd2,0xee,0xd2,0xd5,0xd2,0xd6,0xd2,0xef,0xd2,0xd8,0xb6,0xea,0xd2,0xd9,0xce,0xb2,0xd2,0xdb,0xd2,0xdc,0xd2,0xdd,0xd2,0xde,0xd2,0xdf,0xd2,0xc3,0xd2,0xe1,0xd2,0xe2,0xd2,0xe3,0xd2,0xe4,0xd2,0xe5,0xd2,0xc4,0xd2,0xe7,0xd2,0xe8,0xd2,0xe9,0xe2,0xf8,0xf0,0xea,0xef,0xd7,0xf1,0xaf,0xe2,0xf9,0xe6,0xe4,0xec,0xbd,0xec,0xda,0xf4,0xfd,0xf1,0xb4,0xec,0xa5,0xe1,0xbb,0xdb,0xdd,0xe9,0xec,0xe0,0xc9,0xdf,0xd7,0xdc,0xb2,0xe0,0xe6,0xd8,0xe6,0xda,0xb1,0xe2,0xc2,0xe4,0xf4,0xd8,0xfd,0xdf,0xde,0xf0,0xf9,0xe2,0xa2,0xed,0xf4,0xf4,0xe0,0xde,0xc4,0xdc,0xd3,0xdc,0xe8,0xd8,0xee,0xd9,0xab,0xea,0xdd,0xee,0xc6,0xe7,0xcb,0xe5,0xc6,0xd8,0xd7,0xe3,0xa8,0xf7,0xf0,0xf4,0xe8,0xdf,0xae,0xde,0xc8,0xf2,0xe6,0xdb,0xfc,0xde,0xda,0xe1,0xda,0xde,0xb2,0xdf,0xbd,0xe9,0xf3,0xef,0xee,0x00};

//const unsigned char PY_mb_yin   []={"因引印银音饮阴隐荫吟尹寅茵淫殷姻烟堙鄞喑夤胤龈吲圻狺垠霪蚓氤铟窨瘾洇茚"};
const unsigned char PY_mb_yin   []={0xd2,0xf2,0xd2,0xfd,0xd3,0xa1,0xd2,0xf8,0xd2,0xf4,0xd2,0xfb,0xd2,0xf5,0xd2,0xfe,0xd2,0xf1,0xd2,0xf7,0xd2,0xfc,0xd2,0xfa,0xd2,0xf0,0xd2,0xf9,0xd2,0xf3,0xd2,0xf6,0xd1,0xcc,0xdc,0xa7,0xdb,0xb4,0xe0,0xb3,0xe2,0xb9,0xd8,0xb7,0xf6,0xb8,0xdf,0xc5,0xdb,0xdf,0xe1,0xfe,0xdb,0xf3,0xf6,0xaf,0xf2,0xbe,0xeb,0xb3,0xee,0xf7,0xf1,0xbf,0xf1,0xab,0xe4,0xa6,0xdc,0xe1,0x00};

//const unsigned char PY_mb_ying  []={"应硬影营迎映蝇赢鹰英颖莹盈婴樱缨荧萤萦楹蓥瘿茔鹦媵莺璎郢嘤撄瑛滢潆嬴罂瀛膺荥颍"};
const unsigned char PY_mb_ying  []={0xd3,0xa6,0xd3,0xb2,0xd3,0xb0,0xd3,0xaa,0xd3,0xad,0xd3,0xb3,0xd3,0xac,0xd3,0xae,0xd3,0xa5,0xd3,0xa2,0xd3,0xb1,0xd3,0xa8,0xd3,0xaf,0xd3,0xa4,0xd3,0xa3,0xd3,0xa7,0xd3,0xab,0xd3,0xa9,0xdd,0xd3,0xe9,0xba,0xdd,0xf6,0xf1,0xa8,0xdc,0xe3,0xf0,0xd0,0xeb,0xf4,0xdd,0xba,0xe8,0xac,0xdb,0xab,0xe0,0xd3,0xde,0xfc,0xe7,0xf8,0xe4,0xde,0xe4,0xeb,0xd9,0xf8,0xf3,0xbf,0xe5,0xad,0xe2,0xdf,0xdc,0xfe,0xf2,0xa3,0x00};

//const unsigned char PY_mb_yo    []={"哟育唷"};
const unsigned char PY_mb_yo    []={0xd3,0xb4,0xd3,0xfd,0xe0,0xa1,0x00};

//const unsigned char PY_mb_yong  []={"用涌永拥蛹勇雍咏泳佣踊痈庸臃恿俑壅墉喁慵邕镛甬鳙饔"};
const unsigned char PY_mb_yong  []={0xd3,0xc3,0xd3,0xbf,0xd3,0xc0,0xd3,0xb5,0xd3,0xbc,0xd3,0xc2,0xd3,0xba,0xd3,0xbd,0xd3,0xbe,0xd3,0xb6,0xd3,0xbb,0xd3,0xb8,0xd3,0xb9,0xd3,0xb7,0xd3,0xc1,0xd9,0xb8,0xdb,0xd5,0xdc,0xad,0xe0,0xaf,0xe3,0xbc,0xe7,0xdf,0xef,0xde,0xf0,0xae,0xf7,0xab,0xf7,0xd3,0x00};

//const unsigned char PY_mb_you   []={"有又由右油游幼优友铀忧尤犹诱悠邮酉佑幽釉攸卣侑莠莜莸呦囿宥柚猷牖铕疣蚰蚴蝣鱿黝鼬蝤繇"};
const unsigned char PY_mb_you   []={0xd3,0xd0,0xd3,0xd6,0xd3,0xc9,0xd3,0xd2,0xd3,0xcd,0xd3,0xce,0xd3,0xd7,0xd3,0xc5,0xd3,0xd1,0xd3,0xcb,0xd3,0xc7,0xd3,0xc8,0xd3,0xcc,0xd3,0xd5,0xd3,0xc6,0xd3,0xca,0xd3,0xcf,0xd3,0xd3,0xd3,0xc4,0xd3,0xd4,0xd8,0xfc,0xd8,0xd5,0xd9,0xa7,0xdd,0xac,0xdd,0xaf,0xdd,0xb5,0xdf,0xcf,0xe0,0xf3,0xe5,0xb6,0xe8,0xd6,0xe9,0xe0,0xeb,0xbb,0xee,0xf0,0xf0,0xe0,0xf2,0xc4,0xf2,0xca,0xf2,0xf6,0xf6,0xcf,0xf7,0xee,0xf7,0xf8,0xf2,0xf8,0xf4,0xed,0x00};

//const unsigned char PY_mb_yu    []={"与于欲鱼雨余遇语愈狱玉渔予誉育愚羽虞娱淤舆屿禹宇迂俞逾域芋郁谷吁盂喻峪御愉粥渝尉榆隅浴寓裕预豫驭蔚妪嵛雩馀阈窬鹆妤揄窳觎臾舁龉蓣煜钰谀纡於竽瑜禺聿欤俣伛圄鹬庾昱萸瘐谕鬻圉瘀熨饫毓燠腴狳菀蜮蝓"};
const unsigned char PY_mb_yu    []={0xd3,0xeb,0xd3,0xda,0xd3,0xfb,0xd3,0xe3,0xd3,0xea,0xd3,0xe0,0xd3,0xf6,0xd3,0xef,0xd3,0xfa,0xd3,0xfc,0xd3,0xf1,0xd3,0xe6,0xd3,0xe8,0xd3,0xfe,0xd3,0xfd,0xd3,0xde,0xd3,0xf0,0xd3,0xdd,0xd3,0xe9,0xd3,0xd9,0xd3,0xdf,0xd3,0xec,0xd3,0xed,0xd3,0xee,0xd3,0xd8,0xd3,0xe1,0xd3,0xe2,0xd3,0xf2,0xd3,0xf3,0xd3,0xf4,0xb9,0xc8,0xd3,0xf5,0xd3,0xdb,0xd3,0xf7,0xd3,0xf8,0xd3,0xf9,0xd3,0xe4,0xd6,0xe0,0xd3,0xe5,0xce,0xbe,0xd3,0xdc,0xd3,0xe7,0xd4,0xa1,0xd4,0xa2,0xd4,0xa3,0xd4,0xa4,0xd4,0xa5,0xd4,0xa6,0xce,0xb5,0xe5,0xfd,0xe1,0xce,0xf6,0xa7,0xe2,0xc5,0xe3,0xd0,0xf1,0xbe,0xf0,0xc1,0xe6,0xa5,0xde,0xed,0xf1,0xc1,0xea,0xec,0xf4,0xa7,0xf4,0xa8,0xf6,0xb9,0xdd,0xf7,0xec,0xcf,0xee,0xda,0xda,0xc4,0xe6,0xfa,0xec,0xb6,0xf3,0xc4,0xe8,0xa4,0xd8,0xae,0xed,0xb2,0xec,0xa3,0xd9,0xb6,0xd8,0xf1,0xe0,0xf4,0xf0,0xd6,0xe2,0xd7,0xea,0xc5,0xdd,0xc7,0xf0,0xf5,0xda,0xcd,0xe5,0xf7,0xe0,0xf6,0xf0,0xf6,0xec,0xd9,0xe2,0xc0,0xd8,0xb9,0xec,0xdb,0xeb,0xe9,0xe1,0xfc,0xdd,0xd2,0xf2,0xe2,0xf2,0xf5,0x00};

//const unsigned char PY_mb_yuan  []={"远员元院圆原愿园援猿怨冤源缘袁渊苑垣鸳辕圜鼋橼媛爰眢鸢掾芫沅瑗螈箢塬垸"};
const unsigned char PY_mb_yuan  []={0xd4,0xb6,0xd4,0xb1,0xd4,0xaa,0xd4,0xba,0xd4,0xb2,0xd4,0xad,0xd4,0xb8,0xd4,0xb0,0xd4,0xae,0xd4,0xb3,0xd4,0xb9,0xd4,0xa9,0xd4,0xb4,0xd4,0xb5,0xd4,0xac,0xd4,0xa8,0xd4,0xb7,0xd4,0xab,0xd4,0xa7,0xd4,0xaf,0xe0,0xf7,0xf6,0xbd,0xe9,0xda,0xe6,0xc2,0xeb,0xbc,0xed,0xf3,0xf0,0xb0,0xde,0xf2,0xdc,0xbe,0xe3,0xe4,0xe8,0xa5,0xf3,0xa2,0xf3,0xee,0xdc,0xab,0xdb,0xf9,0x00};

//const unsigned char PY_mb_yue   []={"月越约跃阅乐岳悦曰说粤钥瀹钺刖龠栎樾"};
const unsigned char PY_mb_yue   []={0xd4,0xc2,0xd4,0xbd,0xd4,0xbc,0xd4,0xbe,0xd4,0xc4,0xc0,0xd6,0xd4,0xc0,0xd4,0xc3,0xd4,0xbb,0xcb,0xb5,0xd4,0xc1,0xd4,0xbf,0xe5,0xae,0xee,0xe1,0xeb,0xbe,0xd9,0xdf,0xe8,0xdd,0xe9,0xd0,0x00};

//const unsigned char PY_mb_yun   []={"云运晕允匀韵陨孕耘蕴酝郧员熨氲恽愠郓芸筠韫昀狁殒纭"};
const unsigned char PY_mb_yun   []={0xd4,0xc6,0xd4,0xcb,0xd4,0xce,0xd4,0xca,0xd4,0xc8,0xd4,0xcf,0xd4,0xc9,0xd4,0xd0,0xd4,0xc5,0xd4,0xcc,0xd4,0xcd,0xd4,0xc7,0xd4,0xb1,0xec,0xd9,0xeb,0xb5,0xe3,0xa2,0xe3,0xb3,0xdb,0xa9,0xdc,0xbf,0xf3,0xde,0xe8,0xb9,0xea,0xc0,0xe1,0xf1,0xe9,0xe6,0xe7,0xa1,0x00};

//const unsigned char PY_mb_za    []={"杂砸咋匝扎咱咂拶"};
const unsigned char PY_mb_za    []={0xd4,0xd3,0xd4,0xd2,0xd5,0xa6,0xd4,0xd1,0xd4,0xfa,0xd4,0xdb,0xdf,0xc6,0xde,0xd9,0x00};

//const unsigned char PY_mb_zai   []={"在再灾载栽宰哉崽甾仔"};
const unsigned char PY_mb_zai   []={0xd4,0xda,0xd4,0xd9,0xd4,0xd6,0xd4,0xd8,0xd4,0xd4,0xd4,0xd7,0xd4,0xd5,0xe1,0xcc,0xe7,0xde,0xd7,0xd0,0x00};

//const unsigned char PY_mb_zan   []={"咱暂攒赞簪趱糌瓒拶昝錾"};
const unsigned char PY_mb_zan   []={0xd4,0xdb,0xd4,0xdd,0xd4,0xdc,0xd4,0xde,0xf4,0xa2,0xf4,0xf5,0xf4,0xd8,0xe8,0xb6,0xde,0xd9,0xea,0xc3,0xf6,0xc9,0x00};

//const unsigned char PY_mb_zang  []={"脏葬赃藏臧驵奘"};
const unsigned char PY_mb_zang  []={0xd4,0xe0,0xd4,0xe1,0xd4,0xdf,0xb2,0xd8,0xea,0xb0,0xe6,0xe0,0xde,0xca,0x00};

//const unsigned char PY_mb_zao   []={"早造遭糟灶燥枣凿躁藻皂噪澡蚤唣"};
const unsigned char PY_mb_zao   []={0xd4,0xe7,0xd4,0xec,0xd4,0xe2,0xd4,0xe3,0xd4,0xee,0xd4,0xef,0xd4,0xe6,0xd4,0xe4,0xd4,0xea,0xd4,0xe5,0xd4,0xed,0xd4,0xeb,0xd4,0xe8,0xd4,0xe9,0xdf,0xf0,0x00};

//const unsigned char PY_mb_ze    []={"则责择泽咋侧箦舴帻迮啧仄昃笮赜"};
const unsigned char PY_mb_ze    []={0xd4,0xf2,0xd4,0xf0,0xd4,0xf1,0xd4,0xf3,0xd5,0xa6,0xb2,0xe0,0xf3,0xe5,0xf4,0xb7,0xe0,0xfd,0xe5,0xc5,0xdf,0xf5,0xd8,0xc6,0xea,0xbe,0xf3,0xd0,0xd8,0xd3,0x00};

//const unsigned char PY_mb_zei   []={"贼"};
const unsigned char PY_mb_zei   []={0xd4,0xf4,0x00};

//const unsigned char PY_mb_zen   []={"怎谮"};
const unsigned char PY_mb_zen   []={0xd4,0xf5,0xda,0xda,0x00};

//const unsigned char PY_mb_zeng  []={"增赠憎曾综缯罾甑锃"};
const unsigned char PY_mb_zeng  []={0xd4,0xf6,0xd4,0xf9,0xd4,0xf7,0xd4,0xf8,0xd7,0xdb,0xe7,0xd5,0xee,0xc0,0xea,0xb5,0xef,0xad,0x00};

//const unsigned char PY_mb_zha   []={"扎炸渣闸眨榨乍轧诈喳札铡揸吒咤哳猹砟痄蚱齄查蜡栅咋喋楂柞"};
const unsigned char PY_mb_zha   []={0xd4,0xfa,0xd5,0xa8,0xd4,0xfc,0xd5,0xa2,0xd5,0xa3,0xd5,0xa5,0xd5,0xa7,0xd4,0xfe,0xd5,0xa9,0xd4,0xfb,0xd4,0xfd,0xd5,0xa1,0xde,0xea,0xdf,0xb8,0xdf,0xe5,0xdf,0xee,0xe2,0xaa,0xed,0xc4,0xf0,0xe4,0xf2,0xc6,0xf7,0xfe,0xb2,0xe9,0xc0,0xaf,0xd5,0xa4,0xd5,0xa6,0xe0,0xa9,0xe9,0xab,0xd7,0xf5,0x00};

//const unsigned char PY_mb_zhai  []={"摘窄债斋寨择翟宅侧祭砦瘵"};
const unsigned char PY_mb_zhai  []={0xd5,0xaa,0xd5,0xad,0xd5,0xae,0xd5,0xab,0xd5,0xaf,0xd4,0xf1,0xb5,0xd4,0xd5,0xac,0xb2,0xe0,0xbc,0xc0,0xed,0xce,0xf1,0xa9,0x00};

//const unsigned char PY_mb_zhan  []={"站占战盏沾粘毡展栈詹颤蘸湛绽斩辗崭瞻谵搌旃"};
const unsigned char PY_mb_zhan  []={0xd5,0xbe,0xd5,0xbc,0xd5,0xbd,0xd5,0xb5,0xd5,0xb4,0xd5,0xb3,0xd5,0xb1,0xd5,0xb9,0xd5,0xbb,0xd5,0xb2,0xb2,0xfc,0xd5,0xba,0xd5,0xbf,0xd5,0xc0,0xd5,0xb6,0xd5,0xb7,0xd5,0xb8,0xd5,0xb0,0xda,0xde,0xde,0xf8,0xec,0xb9,0x00};

//const unsigned char PY_mb_zhang []={"张章长帐仗丈掌涨账樟杖彰漳胀瘴障仉嫜幛鄣璋嶂獐蟑"};
const unsigned char PY_mb_zhang []={0xd5,0xc5,0xd5,0xc2,0xb3,0xa4,0xd5,0xca,0xd5,0xcc,0xd5,0xc9,0xd5,0xc6,0xd5,0xc7,0xd5,0xcb,0xd5,0xc1,0xd5,0xc8,0xd5,0xc3,0xd5,0xc4,0xd5,0xcd,0xd5,0xce,0xd5,0xcf,0xd8,0xeb,0xe6,0xd1,0xe1,0xa4,0xdb,0xb5,0xe8,0xb0,0xe1,0xd6,0xe2,0xaf,0xf3,0xaf,0x00};

//const unsigned char PY_mb_zhao  []={"找着照招罩爪兆朝昭沼肇嘲召赵棹钊笊诏啁"};
const unsigned char PY_mb_zhao  []={0xd5,0xd2,0xd7,0xc5,0xd5,0xd5,0xd5,0xd0,0xd5,0xd6,0xd7,0xa6,0xd5,0xd7,0xb3,0xaf,0xd5,0xd1,0xd5,0xd3,0xd5,0xd8,0xb3,0xb0,0xd5,0xd9,0xd5,0xd4,0xe8,0xfe,0xee,0xc8,0xf3,0xc9,0xda,0xaf,0xdf,0xfa,0x00};

//const unsigned char PY_mb_zhe   []={"着这者折遮蛰哲蔗锗辙浙柘辄赭摺鹧磔褶蜇谪"};
const unsigned char PY_mb_zhe   []={0xd7,0xc5,0xd5,0xe2,0xd5,0xdf,0xd5,0xdb,0xd5,0xda,0xd5,0xdd,0xd5,0xdc,0xd5,0xe1,0xd5,0xe0,0xd5,0xde,0xd5,0xe3,0xe8,0xcf,0xe9,0xfc,0xf4,0xf7,0xdf,0xa1,0xf0,0xd1,0xed,0xdd,0xf1,0xde,0xf2,0xd8,0xda,0xd8,0x00};

//const unsigned char PY_mb_zhen  []={"真阵镇针震枕振斟珍疹诊甄砧臻贞侦缜蓁祯箴轸榛稹赈朕鸩胗浈桢畛圳椹"};
const unsigned char PY_mb_zhen  []={0xd5,0xe6,0xd5,0xf3,0xd5,0xf2,0xd5,0xeb,0xd5,0xf0,0xd5,0xed,0xd5,0xf1,0xd5,0xe5,0xd5,0xe4,0xd5,0xee,0xd5,0xef,0xd5,0xe7,0xd5,0xe8,0xd5,0xe9,0xd5,0xea,0xd5,0xec,0xe7,0xc7,0xdd,0xe8,0xec,0xf5,0xf3,0xf0,0xe9,0xf4,0xe9,0xbb,0xf0,0xa1,0xea,0xe2,0xeb,0xde,0xf0,0xb2,0xeb,0xd3,0xe4,0xa5,0xe8,0xe5,0xee,0xb3,0xdb,0xda,0xe9,0xa9,0x00};

//const unsigned char PY_mb_zheng []={"正整睁争挣征怔证症郑拯蒸狰政帧峥钲铮筝诤徵丁鲭"};
const unsigned char PY_mb_zheng []={0xd5,0xfd,0xd5,0xfb,0xd5,0xf6,0xd5,0xf9,0xd5,0xf5,0xd5,0xf7,0xd5,0xfa,0xd6,0xa4,0xd6,0xa2,0xd6,0xa3,0xd5,0xfc,0xd5,0xf4,0xd5,0xf8,0xd5,0xfe,0xd6,0xa1,0xe1,0xbf,0xee,0xdb,0xef,0xa3,0xf3,0xdd,0xda,0xba,0xe1,0xe7,0xb6,0xa1,0xf6,0xeb,0x00};

//const unsigned char PY_mb_zhi   []={"只之直知制指纸支芝枝稚吱蜘质肢脂汁炙织职痔植抵殖执值侄址智滞止趾治旨窒志挚掷至致置帜识峙氏秩帙摭黹桎枳轵忮祉蛭膣觯郅栀彘芷祗咫鸷絷踬胝骘轾痣陟踯雉埴贽卮酯豸跖栉伎"};
const unsigned char PY_mb_zhi   []={0xd6,0xbb,0xd6,0xae,0xd6,0xb1,0xd6,0xaa,0xd6,0xc6,0xd6,0xb8,0xd6,0xbd,0xd6,0xa7,0xd6,0xa5,0xd6,0xa6,0xd6,0xc9,0xd6,0xa8,0xd6,0xa9,0xd6,0xca,0xd6,0xab,0xd6,0xac,0xd6,0xad,0xd6,0xcb,0xd6,0xaf,0xd6,0xb0,0xd6,0xcc,0xd6,0xb2,0xb5,0xd6,0xd6,0xb3,0xd6,0xb4,0xd6,0xb5,0xd6,0xb6,0xd6,0xb7,0xd6,0xc7,0xd6,0xcd,0xd6,0xb9,0xd6,0xba,0xd6,0xce,0xd6,0xbc,0xd6,0xcf,0xd6,0xbe,0xd6,0xbf,0xd6,0xc0,0xd6,0xc1,0xd6,0xc2,0xd6,0xc3,0xd6,0xc4,0xca,0xb6,0xd6,0xc5,0xca,0xcf,0xd6,0xc8,0xe0,0xf9,0xde,0xfd,0xed,0xe9,0xe8,0xe4,0xe8,0xd7,0xe9,0xf2,0xe2,0xe5,0xec,0xed,0xf2,0xce,0xeb,0xf9,0xf6,0xa3,0xdb,0xa4,0xe8,0xd9,0xe5,0xe9,0xdc,0xc6,0xec,0xf3,0xe5,0xeb,0xf0,0xba,0xf4,0xea,0xf5,0xd9,0xeb,0xd5,0xe6,0xef,0xe9,0xf9,0xf0,0xeb,0xda,0xec,0xf5,0xdc,0xef,0xf4,0xdb,0xfa,0xea,0xde,0xd8,0xb4,0xf5,0xa5,0xf5,0xf4,0xf5,0xc5,0xe8,0xce,0xbc,0xbf,0x00};

//const unsigned char PY_mb_zhong []={"中重种钟肿众终盅忠仲衷踵舯螽锺冢忪"};
const unsigned char PY_mb_zhong []={0xd6,0xd0,0xd6,0xd8,0xd6,0xd6,0xd6,0xd3,0xd6,0xd7,0xd6,0xda,0xd6,0xd5,0xd6,0xd1,0xd6,0xd2,0xd6,0xd9,0xd6,0xd4,0xf5,0xe0,0xf4,0xb1,0xf3,0xae,0xef,0xf1,0xda,0xa3,0xe2,0xec,0x00};

//const unsigned char PY_mb_zhou  []={"周洲皱粥州轴舟昼骤宙诌肘帚咒繇胄纣荮啁碡绉籀妯酎"};
const unsigned char PY_mb_zhou  []={0xd6,0xdc,0xd6,0xde,0xd6,0xe5,0xd6,0xe0,0xd6,0xdd,0xd6,0xe1,0xd6,0xdb,0xd6,0xe7,0xd6,0xe8,0xd6,0xe6,0xd6,0xdf,0xd6,0xe2,0xd6,0xe3,0xd6,0xe4,0xf4,0xed,0xeb,0xd0,0xe6,0xfb,0xdd,0xa7,0xdf,0xfa,0xed,0xd8,0xe7,0xa7,0xf4,0xa6,0xe6,0xa8,0xf4,0xfc,0x00};

//const unsigned char PY_mb_zhu   []={"住主猪竹株煮筑著珠蛛朱诸诛逐烛拄瞩嘱柱助蛀贮铸注祝驻伫潴洙瘃翥茱苎橥舳杼箸炷侏铢疰渚褚躅麈邾槠竺属术"};
const unsigned char PY_mb_zhu   []={0xd7,0xa1,0xd6,0xf7,0xd6,0xed,0xd6,0xf1,0xd6,0xea,0xd6,0xf3,0xd6,0xfe,0xd6,0xf8,0xd6,0xe9,0xd6,0xeb,0xd6,0xec,0xd6,0xee,0xd6,0xef,0xd6,0xf0,0xd6,0xf2,0xd6,0xf4,0xd6,0xf5,0xd6,0xf6,0xd6,0xf9,0xd6,0xfa,0xd6,0xfb,0xd6,0xfc,0xd6,0xfd,0xd7,0xa2,0xd7,0xa3,0xd7,0xa4,0xd8,0xf9,0xe4,0xf3,0xe4,0xa8,0xf0,0xf1,0xf4,0xe3,0xdc,0xef,0xdc,0xd1,0xe9,0xcd,0xf4,0xb6,0xe8,0xcc,0xf3,0xe7,0xec,0xc4,0xd9,0xaa,0xee,0xf9,0xf0,0xe6,0xe4,0xbe,0xf1,0xd2,0xf5,0xee,0xf7,0xe6,0xdb,0xa5,0xe9,0xc6,0xf3,0xc3,0xca,0xf4,0xca,0xf5,0x00};

//const unsigned char PY_mb_zhua  []={"抓爪挝"};
const unsigned char PY_mb_zhua  []={0xd7,0xa5,0xd7,0xa6,0xce,0xce,0x00};

//const unsigned char PY_mb_zhuai []={"拽转"};
const unsigned char PY_mb_zhuai []={0xd7,0xa7,0xd7,0xaa,0x00};

//const unsigned char PY_mb_zhuan []={"转专砖赚传撰篆颛馔啭沌"};
const unsigned char PY_mb_zhuan []={0xd7,0xaa,0xd7,0xa8,0xd7,0xa9,0xd7,0xac,0xb4,0xab,0xd7,0xab,0xd7,0xad,0xf2,0xa7,0xe2,0xcd,0xdf,0xf9,0xe3,0xe7,0x00};

//const unsigned char PY_mb_zhuang[]={"装撞庄壮桩状幢妆僮奘戆"};
const unsigned char PY_mb_zhuang[]={0xd7,0xb0,0xd7,0xb2,0xd7,0xaf,0xd7,0xb3,0xd7,0xae,0xd7,0xb4,0xb4,0xb1,0xd7,0xb1,0xd9,0xd7,0xde,0xca,0xed,0xb0,0x00};

//const unsigned char PY_mb_zhui  []={"追坠缀锥赘椎骓惴缒隹"};
const unsigned char PY_mb_zhui  []={0xd7,0xb7,0xd7,0xb9,0xd7,0xba,0xd7,0xb6,0xd7,0xb8,0xd7,0xb5,0xe6,0xed,0xe3,0xb7,0xe7,0xc4,0xf6,0xbf,0x00};

//const unsigned char PY_mb_zhun  []={"准谆屯肫窀"};
const unsigned char PY_mb_zhun  []={0xd7,0xbc,0xd7,0xbb,0xcd,0xcd,0xeb,0xc6,0xf1,0xb8,0x00};

//const unsigned char PY_mb_zhuo  []={"捉桌着啄拙灼浊卓琢缴茁酌擢焯濯诼浞涿倬镯禚斫"};
const unsigned char PY_mb_zhuo  []={0xd7,0xbd,0xd7,0xc0,0xd7,0xc5,0xd7,0xc4,0xd7,0xbe,0xd7,0xc6,0xd7,0xc7,0xd7,0xbf,0xd7,0xc1,0xbd,0xc9,0xd7,0xc2,0xd7,0xc3,0xdf,0xaa,0xec,0xcc,0xe5,0xaa,0xda,0xc2,0xe4,0xb7,0xe4,0xc3,0xd9,0xbe,0xef,0xed,0xec,0xfa,0xed,0xbd,0x00};

//const unsigned char PY_mb_zi    []={"字自子紫籽资姿吱滓仔咨孜渍滋淄谘茈嵫姊孳缁梓辎赀恣眦锱秭耔笫粢趑訾龇鲻髭兹觜"};
const unsigned char PY_mb_zi    []={0xd7,0xd6,0xd7,0xd4,0xd7,0xd3,0xd7,0xcf,0xd7,0xd1,0xd7,0xca,0xd7,0xcb,0xd6,0xa8,0xd7,0xd2,0xd7,0xd0,0xd7,0xc9,0xd7,0xce,0xd7,0xd5,0xd7,0xcc,0xd7,0xcd,0xda,0xd1,0xdc,0xeb,0xe1,0xd1,0xe6,0xa2,0xe6,0xdc,0xe7,0xbb,0xe8,0xf7,0xea,0xa2,0xea,0xdf,0xed,0xa7,0xed,0xf6,0xef,0xc5,0xef,0xf6,0xf1,0xe8,0xf3,0xca,0xf4,0xd2,0xf4,0xf4,0xf6,0xa4,0xf6,0xb7,0xf6,0xf6,0xf7,0xda,0xd7,0xc8,0xf5,0xfe,0x00};

//const unsigned char PY_mb_zong  []={"总纵宗棕综踪鬃偬粽枞腙"};
const unsigned char PY_mb_zong  []={0xd7,0xdc,0xd7,0xdd,0xd7,0xda,0xd7,0xd8,0xd7,0xdb,0xd7,0xd9,0xd7,0xd7,0xd9,0xcc,0xf4,0xd5,0xe8,0xc8,0xeb,0xea,0x00};

//const unsigned char PY_mb_zou   []={"走揍奏邹鲰鄹陬驺诹"};
const unsigned char PY_mb_zou   []={0xd7,0xdf,0xd7,0xe1,0xd7,0xe0,0xd7,0xde,0xf6,0xed,0xdb,0xb8,0xda,0xee,0xe6,0xe3,0xda,0xc1,0x00};

//const unsigned char PY_mb_zu    []={"组族足阻租祖诅菹镞卒俎"};
const unsigned char PY_mb_zu    []={0xd7,0xe9,0xd7,0xe5,0xd7,0xe3,0xd7,0xe8,0xd7,0xe2,0xd7,0xe6,0xd7,0xe7,0xdd,0xcf,0xef,0xdf,0xd7,0xe4,0xd9,0xde,0x00};

//const unsigned char PY_mb_zuan  []={"钻纂赚攥缵躜"};
const unsigned char PY_mb_zuan  []={0xd7,0xea,0xd7,0xeb,0xd7,0xac,0xdf,0xac,0xe7,0xda,0xf5,0xf2,0x00};

//const unsigned char PY_mb_zui   []={"最嘴醉罪堆咀觜蕞"};
const unsigned char PY_mb_zui   []={0xd7,0xee,0xd7,0xec,0xd7,0xed,0xd7,0xef,0xb6,0xd1,0xbe,0xd7,0xf5,0xfe,0xde,0xa9,0x00};

//const unsigned char PY_mb_zun   []={"尊遵撙樽鳟"};
const unsigned char PY_mb_zun   []={0xd7,0xf0,0xd7,0xf1,0xdf,0xa4,0xe9,0xd7,0xf7,0xae,0x00};

//const unsigned char PY_mb_zuo   []={"做作坐左座昨凿佐阼唑怍胙祚撮琢嘬笮酢柞"};
const unsigned char PY_mb_zuo   []={0xd7,0xf6,0xd7,0xf7,0xd7,0xf8,0xd7,0xf3,0xd7,0xf9,0xd7,0xf2,0xd4,0xe4,0xd7,0xf4,0xda,0xe8,0xdf,0xf2,0xe2,0xf4,0xeb,0xd1,0xec,0xf1,0xb4,0xe9,0xd7,0xc1,0xe0,0xdc,0xf3,0xd0,0xf5,0xa1,0xd7,0xf5,0x00};

//const unsigned char PY_mb_bd    []={",.?!:;'\"()<>[]{}$%@*+-_=~`|/\\^&*"};
const unsigned char PY_mb_bd    []={0x2c,0x2e,0x3f,0x21,0x3a,0x3b,0x27,0x5c,0x22,0x28,0x29,0x3c,0x3e,0x5b,0x5d,0x00};

//const unsigned char PY_mb_sz    []={"0123456789"}; //数字
const unsigned char PY_mb_sz    []={0x30,0x31,0x32,0x33,0x34,0x35,0x36,0x37,0x38,0x39,0x00};

//const unsigned char PY_mb_abc   []={"abc"};
const unsigned char PY_mb_abc   []={0x61,0x62,0x63,0x00};

//const unsigned char PY_mb_def   []={"def"};
const unsigned char PY_mb_def   []={0x64,0x65,0x66,0x00};

//const unsigned char PY_mb_ghi   []={"ghi"};
const unsigned char PY_mb_ghi   []={0x67,0x68,0x69,0x00};

//const unsigned char PY_mb_jkl   []={"jkl"};
const unsigned char PY_mb_jkl   []={0x6a,0x6b,0x6c,0x00};

//const unsigned char PY_mb_mno   []={"mno"};
const unsigned char PY_mb_mno   []={0x6d,0x6e,0x6f,0x00};

//const unsigned char PY_mb_pqrs  []={"pqrs"};
const unsigned char PY_mb_pqrs  []={0x70,0x71,0x72,0x73,0x00};

//const unsigned char PY_mb_tuv   []={"tuv"};
const unsigned char PY_mb_tuv   []={0x74,0x75,0x76,0x00};

//const unsigned char PY_mb_wxyz  []={"wxyz"};
const unsigned char PY_mb_wxyz  []={0x77,0x78,0x79,0x7a,0x00};

//const unsigned char PY_mb_ABC   []={"ABC"};
const unsigned char PY_mb_ABC   []={0x41,0x42,0x43,0x00};

//const unsigned char PY_mb_DEF   []={"DEF"};
const unsigned char PY_mb_DEF   []={0x44,0x45,0x46,0x00};

//const unsigned char PY_mb_GHI   []={"GHI"};
const unsigned char PY_mb_GHI   []={0x47,0x48,0x49,0x00};

//const unsigned char PY_mb_JKL   []={"JKL"};
const unsigned char PY_mb_JKL   []={0x4a,0x4b,0x4c,0x00};

//const unsigned char PY_mb_MNO   []={"MNO"};
const unsigned char PY_mb_MNO   []={0x4d,0x4e,0x4f,0x00};

//const unsigned char PY_mb_PQRS  []={"PQRS"};
const unsigned char PY_mb_PQRS  []={0x50,0x51,0x52,0x53,0x00};

//const unsigned char PY_mb_TUV   []={"TUV"};
const unsigned char PY_mb_TUV   []={0x54,0x55,0x56,0x00};

//const unsigned char PY_mb_WXYZ  []={"WXYZ"};
const unsigned char PY_mb_WXYZ  []={0x57,0x58,0x59,0x5a,0x00};


#endif

#endif
 



/*"拼音输入法查询码表,T9数字字母索引表(index)"*/

const struct t9PY_index  t9PY_index0[] ={0x00," ",PY_mb_bd};		//1
const struct t9PY_index  t9PY_index1[] ={0x20," ",PY_mb_space};	//1


const struct t9PY_index  t9PY_index2[] ={{0x2,"a",PY_mb_a},	   //55
										 {0x22,"ba",PY_mb_ba},
										 {0x22,"ca",PY_mb_ca},
										 {0x224,"bai",PY_mb_bai},
										 {0x224,"cai",PY_mb_cai},
										 {0x226,"ban",PY_mb_ban},
										 {0x226,"bao",PY_mb_bao},
										 {0x226,"can",PY_mb_can},
                                         {0x226,"cao",PY_mb_cao},
									     {0x226,"cen",PY_mb_cen},
										 {0x2264,"bang",PY_mb_bang},
									     {0x2264,"cang",PY_mb_cang},
										 {0x23,"ce",PY_mb_ce},
										 {0x234,"bei",PY_mb_bei},
                                         {0x236,"ben",PY_mb_ben},
										 {0x2364,"beng",PY_mb_beng},
                                         {0x2364,"ceng",PY_mb_ceng},
										 {0x24,"ai",PY_mb_ai},
										 {0x24,"bi",PY_mb_bi},
										 {0x24,"ci",PY_mb_ci},
                                    	 {0x242,"cha",PY_mb_cha},
										 {0x2424,"chai",PY_mb_chai},
									     {0x2426,"bian",PY_mb_bian},
                                         {0x2426,"biao",PY_mb_biao},
                                         {0x2426,"chan",PY_mb_chan},
                                         {0x2426,"chao",PY_mb_chao},
										 {0x24264,"chang",PY_mb_chang},
										 {0x243,"bie",PY_mb_bie},
										 {0x243,"che",PY_mb_che},
										 {0x2436,"chen",PY_mb_chen},
										 {0x24364,"cheng",PY_mb_cheng},
										 {0x244,"chi",PY_mb_chi},
										 {0x246,"bin",PY_mb_bin},
										 {0x2464,"bing",PY_mb_bing},
                                         {0x24664,"chong",PY_mb_chong},
										 {0x2468,"chou",PY_mb_chou},
                                         {0x248,"chu",PY_mb_chu},
										 {0x24824,"chuai",PY_mb_chuai},
                                         {0x24826,"chuan",PY_mb_chuan},
										 {0x248264,"chuang",PY_mb_chuang},
										 {0x2484,"chui",PY_mb_chui},
                                         {0x2484,"chun",PY_mb_chun},
                                         {0x2486,"chuo",PY_mb_chuo},										
										 {0x26,"an",PY_mb_an},
                                    	 {0x26,"ao",PY_mb_ao},                   	
                                    	 {0x26,"bo",PY_mb_bo},
                                    	 {0x264,"ang",PY_mb_ang},
										 {0x2664,"cong",PY_mb_cong},
										 {0x268,"cou",PY_mb_cou},
										 {0x28,"bu",PY_mb_bu},
                                    	 {0x28,"cu",PY_mb_cu},
										 {0x2826,"cuan",PY_mb_cuan},
										 {0x284,"cui",PY_mb_cui},
                                         {0x286,"cun",PY_mb_cun},
                                         {0x286,"cuo",PY_mb_cuo}	
										 };	 
const struct t9PY_index  t9PY_index3[] ={{0x03,"e",PY_mb_e},		//33
                                    	 {0x32,"da",PY_mb_da},
                                    	 {0x32,"fa",PY_mb_fa},
                                    	 {0x324,"dai",PY_mb_dai},
										 {0x326,"dan",PY_mb_dan},
									     {0x326,"dao",PY_mb_dao},
									     {0x326,"fan",PY_mb_fan}, 
										 {0x3264,"dang",PY_mb_dang},
                                         {0x3264,"fang",PY_mb_fang},										 
										 {0x33,"de",PY_mb_de},
                                    	 {0x334,"fei",PY_mb_fei},
										 {0x336,"fen",PY_mb_fen},
										 {0x3364,"deng",PY_mb_deng},
                                         {0x3364,"feng",PY_mb_feng},
										 {0x34,"di",PY_mb_di},
                                    	 {0x342,"dia",PY_mb_dia},
										 {0x3426,"dian",PY_mb_dian},
                                         {0x3426,"diao",PY_mb_diao},
                                         {0x343,"die",PY_mb_die},
										 {0x3464,"ding",PY_mb_ding},
										 {0x348,"diu",PY_mb_diu},
										 {0x36,"en",PY_mb_en},
										 {0x36,"fo",PY_mb_fo},
                                    	 {0x3664,"dong",PY_mb_dong},
										 {0x368,"dou",PY_mb_dou},
									     {0x368,"fou",PY_mb_fou},										 
										 {0x37,"er",PY_mb_er},
                                    	 {0x38,"du",PY_mb_du},
                                    	 {0x38,"fu",PY_mb_fu},
                                         {0x3826,"duan",PY_mb_duan},
										 {0x384,"dui",PY_mb_dui},
                                         {0x386,"dun",PY_mb_dun},
                                         {0x386,"duo",PY_mb_duo}                                         
									     };
const struct t9PY_index  t9PY_index4[] ={{0x42,"ha",PY_mb_ha},	   //38
                                         {0x42,"ga",PY_mb_ga},
                                         {0x423,"hai",PY_mb_hai},
										 {0x424,"gai",PY_mb_gai},
                                         {0x426,"gan",PY_mb_gan},
                                         {0x426,"gao",PY_mb_gao},
									     {0x426,"han",PY_mb_han},
                                         {0x426,"hao",PY_mb_hao}, 
										 {0x4264,"gang",PY_mb_gang},
                                         {0x4264,"hang",PY_mb_hang},
										 {0x43,"ge",PY_mb_ge},
                                         {0x43,"he",PY_mb_he},
                                         {0x434,"gei",PY_mb_gei},
									     {0x434,"hei",PY_mb_hei},
										 {0x436,"gen",PY_mb_gan},
									     {0x436,"hen",PY_mb_hen},
										 {0x4364,"geng",PY_mb_geng},
                                         {0x4364,"heng",PY_mb_heng},
										 {0x4664,"gong",PY_mb_gong},
                                         {0x4664,"hong",PY_mb_hong},
										 {0x468,"gou",PY_mb_gou},
                                         {0x468,"hou",PY_mb_hou},
										 {0x48,"gu",PY_mb_gu},
                                         {0x48,"hu",PY_mb_hu},
									     {0x482,"gua",PY_mb_gua},
                                         {0x482,"hua",PY_mb_hua},
                                         {0x4823,"huai",PY_mb_huai},
										 {0x4824,"guai",PY_mb_guai},                                         
									     {0x4826,"guan",PY_mb_guan},
                                         {0x4826,"huan",PY_mb_huan},
                                         {0x48264,"guang",PY_mb_guang},
                                         {0x48264,"huang",PY_mb_huang},
									     {0x484,"gui",PY_mb_gui},
                                         {0x484,"hui",PY_mb_hui},
									     {0x486,"gun",PY_mb_gun},
                                         {0x486,"guo",PY_mb_guo},
                                         {0x486,"hun",PY_mb_hun},
                                         {0x486,"huo",PY_mb_huo}
								      	 };
const struct t9PY_index  t9PY_index5[] ={{0x52,"ka",PY_mb_ka},	  	//57
                                    	 {0x52,"la",PY_mb_la},
                                    	 {0x524,"kai",PY_mb_kai},
                                         {0x524,"lai",PY_mb_lai},                                         
										 {0x526,"kan",PY_mb_kan},
                                         {0x526,"kao",PY_mb_kao},
                                         {0x526,"lan",PY_mb_lan},
                                         {0x526,"lao",PY_mb_lao},
										 {0x5264,"kang",PY_mb_kang},
                                         {0x5264,"lang",PY_mb_lang},
										 {0x53,"ke",PY_mb_ke},
                                    	 {0x53,"le",PY_mb_le},
                                    	 {0x534,"lei",PY_mb_lei},
									     {0x536,"ken",PY_mb_ken},
										 {0x5364,"keng",PY_mb_keng},
									     {0x5366,"leng",PY_mb_leng}, 
										 {0x54,"ji",PY_mb_ji},
										 {0x54,"li",PY_mb_li},
                                    	 {0x542,"jia",PY_mb_jia},
                                         {0x542,"lia",PY_mb_lia},
										 {0x5426,"jian",PY_mb_jian},
                                         {0x5426,"jiao",PY_mb_jiao},
                                         {0x5426,"lian",PY_mb_lian},
                                         {0x5426,"liao",PY_mb_liao},
										 {0x54264,"jiang",PY_mb_jiang},
                                         {0x54264,"liang",PY_mb_liang},									     
										 {0x543,"jie",PY_mb_jie},
                                         {0x543,"lie",PY_mb_lie},
										 {0x546,"jin",PY_mb_jin},
                                   	     {0x546,"lin",PY_mb_lin},
										 {0x5464,"jing",PY_mb_jing},
                                   	     {0x5464,"ling",PY_mb_ling},
										 {0x54664,"jiong",PY_mb_jiong},
										 {0x548,"jiu",PY_mb_jiu},
                                         {0x548,"liu",PY_mb_liu},
										 {0x5664,"kong",PY_mb_kong},
									     {0x5664,"long",PY_mb_long},
										 {0x568,"kou",PY_mb_kou},
									     {0x568,"lou",PY_mb_lou},										 
										 {0x58,"ju",PY_mb_ju},
                                    	 {0x58,"ku",PY_mb_ku},
                                    	 {0x58,"lu",PY_mb_lu},
                                    	 {0x58,"lv",PY_mb_lv},									     
									     {0x582,"kua",PY_mb_kua},
									     {0x5824,"kuai",PY_mb_kuai},
									     {0x5826,"juan",PY_mb_juan},
                                         {0x5826,"kuan",PY_mb_kuan},
                                         {0x5826,"luan",PY_mb_luan},									                                         
									     {0x58264,"kuang",PY_mb_kuang},
										 {0x583,"jue",PY_mb_jue},
                                         {0x583,"lue",PY_mb_lue},
								         {0x584,"kui",PY_mb_kui},	
									     {0x586,"jun",PY_mb_jun},
                                         {0x586,"kun",PY_mb_kun},
                                         {0x586,"kuo",PY_mb_kuo},
                                         {0x586,"lun",PY_mb_lun},
                                         {0x586,"luo",PY_mb_luo}
										 };
const struct t9PY_index  t9PY_index6[] ={{0x06,"o",PY_mb_o},	   //44
										 {0x62,"ma",PY_mb_ma},
                                    	 {0x62,"na",PY_mb_na},
                                    	 {0x624,"mai",PY_mb_mai},
                                         {0x624,"nai",PY_mb_nai},
									     {0x626,"man",PY_mb_man},
                                         {0x626,"mao",PY_mb_mao},
									     {0x626,"nan",PY_mb_nan},
                                         {0x626,"nao",PY_mb_nao},
										 {0x6264,"mang",PY_mb_mang},
                                         {0x6264,"nang",PY_mb_nang},										 
										 {0x63,"me",PY_mb_me},
                                    	 {0x63,"ne",PY_mb_ne},
                                    	 {0x634,"mei",PY_mb_mei},
                                         {0x634,"nei",PY_mb_nei},                                    
									     {0x636,"men",PY_mb_men},
                                         {0x636,"nen",PY_mb_nen},
										 {0x6364,"meng",PY_mb_meng},
                                         {0x6364,"neng",PY_mb_neng},
										 {0x64,"mi",PY_mb_mi},
                                    	 {0x64,"ni",PY_mb_ni},
                                    	 {0x6426,"mian",PY_mb_mian},
                                         {0x6426,"miao",PY_mb_miao},
                                         {0x6426,"nian",PY_mb_nian},
                                         {0x6426,"niao",PY_mb_niao},									     
										 {0x64264,"niang",PY_mb_niang},
										 {0x643,"mie",PY_mb_mie},
									     {0x643,"nie",PY_mb_nie},
                                         {0x646,"min",PY_mb_min},
                                      	 {0x646,"nin",PY_mb_nin},
										 {0x6464,"ming",PY_mb_ming},
                                         {0x6464,"ning",PY_mb_ning},
								         {0x648,"miu",PY_mb_miu},
                                         {0x648,"niu",PY_mb_niu},										 
										 {0x66,"mo",PY_mb_mo},
                                    	 {0x6664,"nong",PY_mb_nong},
										 {0x668,"mou",PY_mb_mou},
										 {0x68,"mu",PY_mb_mu},
                                    	 {0x68,"nu",PY_mb_nu},
                                    	 {0x68,"nv",PY_mb_nv},
                                    	 {0x68,"ou",PY_mb_ou},
                                         {0x6826,"nuan",PY_mb_nuan},
										 {0x683,"nue",PY_mb_nue},
                                         {0x686,"nuo",PY_mb_nuo}                                         
									     };
const struct t9PY_index  t9PY_index7[] ={{0x72,"pa",PY_mb_pa},		 //79
                                    	 {0x72,"sa",PY_mb_sa},
                                    	 {0x724,"pai",PY_mb_pai},
									     {0x724,"sai",PY_mb_sai},
                                         {0x726,"pan",PY_mb_pan},
                                         {0x726,"pao",PY_mb_pao},
                                         {0x726,"ran",PY_mb_ran},
                                         {0x726,"rao",PY_mb_rao},
									     {0x726,"sao",PY_mb_sao},
                                         {0x726,"san",PY_mb_san},
										 {0x7264,"pang",PY_mb_pang},
                                  	     {0x7264,"rang",PY_mb_rang},
								   	     {0x7264,"sang",PY_mb_sang},
										 {0x73,"re",PY_mb_re},
                                    	 {0x73,"se",PY_mb_se},
                                    	 {0x734,"pei",PY_mb_pei},
                                         {0x736,"pen",PY_mb_pen},
                                         {0x736,"ren",PY_mb_ren},
								         {0x736,"sen",PY_mb_sen},
										 {0x7364,"peng",PY_mb_peng},
                                   	     {0x7364,"reng",PY_mb_reng},
								   	     {0x7364,"seng",PY_mb_seng},
										 {0x74,"pi",PY_mb_pi},
                                    	 {0x74,"qi",PY_mb_qi},
                                    	 {0x74,"ri",PY_mb_ri},
										 {0x74,"si",PY_mb_si},
										 {0x742,"sha",PY_mb_sha},
									     {0x742,"qia",PY_mb_qia},
                                         {0x7424,"shai",PY_mb_shai},
									     {0x7426,"pian",PY_mb_pian},
                                         {0x7426,"piao",PY_mb_piao},
                                         {0x7426,"qian",PY_mb_qian},
                                         {0x7426,"qiao",PY_mb_qiao},
									     {0x7426,"shan",PY_mb_shan},
                                         {0x7426,"shao",PY_mb_shao},
										 {0x74264,"qiang",PY_mb_qiang},
										 {0x74264,"shang",PY_mb_shang},
										 {0x743,"qie",PY_mb_qie},
                                         {0x743,"pie",PY_mb_pie},
                                         {0x743,"she",PY_mb_she},
										 {0x7436,"shen",PY_mb_shen},
										 {0x74364,"sheng",PY_mb_sheng},
										 {0x744,"shi",PY_mb_shi},								
									     {0x746,"pin",PY_mb_pin},
										 {0x746,"qin",PY_mb_qin},
                                         {0x7464,"ping",PY_mb_ping},                                   
                                         {0x7464,"qing",PY_mb_qing},
								         {0x74664,"qiong",PY_mb_qiong},
										 {0x7468,"shou",PY_mb_shou},
										 {0x748,"qiu",PY_mb_qiu},
                                   	     {0x748,"shu",PY_mb_shu},
                                         {0x7482,"shua",PY_mb_shua},
                                         {0x74824,"shuai",PY_mb_shuai},
                                         {0x74826,"shuan",PY_mb_shuan},
										 {0x748264,"shuang",PY_mb_shuang},
										 {0x7484,"shui",PY_mb_shui},
                                         {0x7486,"shun",PY_mb_shun},
                                         {0x7486,"shuo",PY_mb_shuo},
										 {0x76,"po",PY_mb_po},
                                    	 {0x7664,"rong",PY_mb_rong},
									     {0x7664,"song",PY_mb_song},
										 {0x768,"pou",PY_mb_pou},                                         
                                         {0x768,"rou",PY_mb_rou},
									     {0x768,"sou",PY_mb_sou},
										 {0x78,"pu",PY_mb_pu},
                                    	 {0x78,"qu",PY_mb_qu},
                                    	 {0x78,"ru",PY_mb_ru},
                                    	 {0x78,"su",PY_mb_su},
									     {0x7826,"quan",PY_mb_quan},
                                         {0x7826,"ruan",PY_mb_ruan},
                                         {0x7826,"suan",PY_mb_suan},
										 {0x783,"que",PY_mb_que},
                                         {0x784,"rui",PY_mb_rui},
									     {0x784,"sui",PY_mb_sui},									
									     {0x786,"qun",PY_mb_qun},
                                         {0x786,"run",PY_mb_run},
                                         {0x786,"ruo",PY_mb_ruo},
                                         {0x786,"sun",PY_mb_sun},
                                         {0x786,"suo",PY_mb_suo}                                   
									     };
const struct t9PY_index  t9PY_index8[] ={{0x82,"ta",PY_mb_ta},	 //19
                                    	 {0x824,"tai",PY_mb_tai},
                                         {0x826,"tan",PY_mb_tan},                                         
										 {0x826,"tao",PY_mb_tao},
										 {0x8264,"tang",PY_mb_tang},
										 {0x83,"te",PY_mb_te},
                                    	 {0x8364,"teng",PY_mb_teng},
										 {0x84,"ti",PY_mb_ti},
                                    	 {0x8426,"tian",PY_mb_tian},
                                         {0x8426,"tiao",PY_mb_tiao},
										 {0x843,"tie",PY_mb_tie},
										 {0x8464,"ting",PY_mb_ting},
										 {0x8664,"tong",PY_mb_tong},
										 {0x868,"tou",PY_mb_tou},
										 {0x88,"tu",PY_mb_tu},
                                         {0x8826,"tuan",PY_mb_tuan},
										 {0x884,"tui",PY_mb_tui},
                                         {0x886,"tun",PY_mb_tun},
                                         {0x886,"tuo",PY_mb_tuo}                                         
									     };
const struct t9PY_index  t9PY_index9[] ={{0x92,"wa",PY_mb_wa},	  //74
                                    	 {0x92,"ya",PY_mb_ya},
                                    	 {0x92,"za",PY_mb_za},
                                    	 {0x924,"wai",PY_mb_wai},
									     {0x924,"zai",PY_mb_zai},
                                         {0x926,"wan",PY_mb_wan},
									     {0x926,"yan",PY_mb_yan},
                                         {0x926,"yao",PY_mb_yao},
									     {0x926,"zan",PY_mb_zan},
                                         {0x926,"zao",PY_mb_zao},
										 {0x9264,"wang",PY_mb_wang},
									     {0x9264,"yang",PY_mb_yang},
                                         {0x9264,"zang",PY_mb_zang},
										 {0x93,"ye",PY_mb_ye},
                                    	 {0x93,"ze",PY_mb_ze},
                                    	 {0x934,"wei",PY_mb_wei},
									     {0x934,"zei",PY_mb_zei},
                                         {0x936,"wen",PY_mb_wen},
                                         {0x936,"zen",PY_mb_zen},
										 {0x9364,"weng",PY_mb_weng},
                                         {0x9364,"zeng",PY_mb_zeng},
										 {0x94,"xi",PY_mb_xi},
                                    	 {0x94,"yi",PY_mb_yi},
                                    	 {0x94,"zi",PY_mb_zi},
                                    	 {0x942,"xia",PY_mb_xia},
                                   	     {0x942,"zha",PY_mb_zha},
								         {0x9424,"zhai",PY_mb_zhai},
									     {0x9426,"xian",PY_mb_xian},
                                         {0x9426,"xiao",PY_mb_xiao},
                                         {0x9426,"zhan",PY_mb_zhan},
                                         {0x9426,"zhao",PY_mb_zhao},
										 {0x94264,"xiang",PY_mb_xiang},
                                         {0x94264,"zhang",PY_mb_zhang},
										 {0x943,"xie",PY_mb_xie},
                                   	     {0x943,"zhe",PY_mb_zhe},
								   	     {0x9436,"zhen",PY_mb_zhen},
										 {0x94364,"zheng",PY_mb_zheng},
										 {0x944,"zhi",PY_mb_zhi},
								         {0x946,"xin",PY_mb_xin},
                                   	     {0x946,"yin",PY_mb_yin},
								         {0x9464,"xing",PY_mb_xing},
                                         {0x9464,"ying",PY_mb_ying},
										 {0x94664,"xiong",PY_mb_xiong},
                                         {0x94664,"zhong",PY_mb_zhong},
										 {0x9468,"zhou",PY_mb_zhou},
										 {0x948,"xiu",PY_mb_xiu},
                                   	     {0x948,"zhu",PY_mb_zhu},
									     {0x9482,"zhua",PY_mb_zhua},
                                         {0x94824,"zhuai",PY_mb_zhuai},
                                         {0x94826,"zhuan",PY_mb_zhuan},
                                         {0x948264,"zhuang",PY_mb_zhuang},
										 {0x9484,"zhui",PY_mb_zhui},
                                         {0x9486,"zhun",PY_mb_zhun},
                                         {0x9486,"zhuo",PY_mb_zhuo},
										 {0x96,"wo",PY_mb_wo},
										 {0x96,"yo",PY_mb_yo},
                                    	 {0x9664,"yong",PY_mb_yong},
								         {0x9664,"zong",PY_mb_zong},
										 {0x968,"you",PY_mb_you},
								         {0x968,"zou",PY_mb_zou},
										 {0x98,"wu",PY_mb_wu},
                                    	 {0x98,"xu",PY_mb_xu},
                                    	 {0x98,"yu",PY_mb_yu},
                                    	 {0x98,"zu",PY_mb_zu},									
									     {0x9826,"xuan",PY_mb_xuan},
                                         {0x9826,"yuan",PY_mb_yuan},
                                         {0x9826,"zuan",PY_mb_zuan},
										 {0x983,"xue",PY_mb_xue},
									     {0x983,"yue",PY_mb_yue},
                                         {0x984,"zui",PY_mb_zui},
									     {0x986,"xun",PY_mb_xun},
									     {0x986,"yun",PY_mb_yun},
                                         {0x986,"zun",PY_mb_zun},
                                         {0x986,"zuo",PY_mb_zuo}
										 };

const uint8_t t9PY_indexlen[10] = {1,1,55,33,38,57,44,79,19,74};   //以每个数字键开始的拼音代码组合数量

const struct t9PY_index  t9PY_sz[] ={{0x00,"0",&PY_mb_sz[0]},
	  								 {0x01,"1",&PY_mb_sz[1]},
									 {0x02,"2",&PY_mb_sz[2]},
	  								 {0x03,"3",&PY_mb_sz[3]},
									 {0x04,"4",&PY_mb_sz[4]},
	  								 {0x05,"5",&PY_mb_sz[5]},
									 {0x06,"6",&PY_mb_sz[6]},
	  								 {0x07,"7",&PY_mb_sz[7]},
									 {0x08,"8",&PY_mb_sz[8]},
	  								 {0x09,"9",&PY_mb_sz[9]}
                                    }; 
const struct t9PY_index  t9PY_abc[] ={{0x00,"",PY_mb_space},
	  								 {0x01,"",PY_mb_space},
									 {0x02,"abc",PY_mb_abc},
	  								 {0x03,"def",PY_mb_def},
									 {0x04,"ghi",PY_mb_ghi},
									 {0x05,"jkl",PY_mb_jkl},
	  								 {0x06,"mno",PY_mb_mno},
									 {0x07,"pqrs",PY_mb_pqrs},
	  								 {0x08,"tuv",PY_mb_tuv},
									 {0x09,"wxyz",PY_mb_wxyz}	  								 
                                     };
const struct t9PY_index  t9PY_ABC[] ={{0x00,"",PY_mb_space},
	  								 {0x01,"",PY_mb_space},
									 {0x02,"ABC",PY_mb_ABC},
	  								 {0x03,"DEF",PY_mb_DEF},
									 {0x04,"GHI",PY_mb_GHI},
									 {0x05,"JKL",PY_mb_JKL},
	  								 {0x06,"MNO",PY_mb_MNO},
									 {0x07,"PQRS",PY_mb_PQRS},
	  								 {0x08,"TUV",PY_mb_TUV},
									 {0x09,"WXYZ",PY_mb_WXYZ}	  								 
                                     };
const struct t9PY_index  *t9PY_index_headno[]={t9PY_index0,
										       t9PY_index1,
											   t9PY_index2,
											   t9PY_index3,
											   t9PY_index4,
											   t9PY_index5,
											   t9PY_index6,
											   t9PY_index7,
											   t9PY_index8,
											   t9PY_index9}; 


#if 0
/*******************************************************************************
**功能：输入法索引程序
**创建：magicchip
**日期：20080509
*******************************************************************************/
void py_index_sub(void)
{
	uint8_t i;
	uint8_t flag = 0x55;
	uint32_t temp;
	uint8_t mblentemp;
	mblentemp = t9pyfun.mblen;

	t9pyfun.mblen = 0x00;
	if ((t9pyfun.pysrf == T9PY) && (t9pyfun.firstno != ' '))		   //拼音输入法
	{
	   for (i=0;i<t9PY_indexlen[t9pyfun.firstno];i++)					//遍历拼音索引表	t9PY_indexlen：索引表的长度	
	   {
	   	   if (t9pyfun.t9py == (*(t9PY_index_headno[t9pyfun.firstno]+i)).t9PY)//比较索引码
		   {
		   	   t9pyfun.mblen++;												//码表长度
			   flag = 0xaa;
			   t9pyfun.t9PY_addr = (t9PY_index_headno[t9pyfun.firstno]+i);	//指向索引表地址
			   for (i++;i<t9PY_indexlen[t9pyfun.firstno];i++)
			   {
			   	  if (t9pyfun.t9py == (*(t9PY_index_headno[t9pyfun.firstno]+i)).t9PY)
				      t9pyfun.mblen++;
				  else 
				  	break;
			   }
			   break;
		   }
	   }
	   if (flag == 0x55)		   //没有查找完全对应的拼音组合，
	   {
	   	  for (i=0;i<t9PY_indexlen[t9pyfun.firstno];i++)
	   	  {
	   	      temp = (*(t9PY_index_headno[t9pyfun.firstno]+i)).t9PY;
			  while (temp > t9pyfun.t9py)
			  {
				 temp >>= 4;
				 if (temp == t9pyfun.t9py)
				 {
				 	t9pyfun.t9PY_addr = t9PY_index_headno[t9pyfun.firstno]+i;
					t9pyfun.mblen++;
					i = t9PY_indexlen[t9pyfun.firstno];
					flag = 0xaa;
					break;
				 }
			  }			 
	      }
		  if (flag == 0x55)
		  {
	   		  t9pyfun.t9py >>= 4;
		   	  t9pyfun.mblen = mblentemp;
		   }
	   }
	   
	}
	else if(t9pyfun.pysrf == T9SZ)			 //数字输入
	{
		t9pyfun.mblen++;
		t9pyfun.t9PY_addr = &t9PY_sz[t9pyfun.firstno];
	}
	else if(t9pyfun.pysrf == T9BD)			//标点输入
	{
		t9pyfun.mblen++;
		t9pyfun.t9PY_addr = t9PY_index0;
	} 
	else if(t9pyfun.pysrf == T9DX)			//大写英文字母输入
	{
		if ((t9pyfun.firstno>1)&&(t9pyfun.firstno<10))
		{
			t9pyfun.mblen++;
			t9pyfun.t9PY_addr = &t9PY_ABC[t9pyfun.firstno];
		}
	} 
	else if(t9pyfun.pysrf == T9XX)			//小写英文字母输入
	{
		if ((t9pyfun.firstno>1)&&(t9pyfun.firstno<10))
		{
			t9pyfun.mblen++;
			t9pyfun.t9PY_addr = &t9PY_abc[t9pyfun.firstno];
		}
	}
}

#else

void py_index_sub(void)
{
	uint8_t i;
	uint8_t flag = 0x55;
	uint32_t temp;
	uint8_t mblentemp;
	mblentemp = t9pyfun.mblen;

	t9pyfun.mblen = 0x00;
	if ((t9pyfun.pysrf == T9PY) && (t9pyfun.firstno != ' ') &&(t9pyfun.firstno>1)&&(t9pyfun.firstno<10))		   //拼音输入法
	{

#if 0
	   for (i=0;i<t9PY_indexlen[t9pyfun.firstno];i++)					//遍历拼音索引表	t9PY_indexlen：索引表的长度	
	   {
	   	   if (t9pyfun.t9py == (*(t9PY_index_headno[t9pyfun.firstno]+i)).t9PY)//比较索引码
		   {
		   	   t9pyfun.mblen++;												//码表长度
			   flag = 0xaa;
			   t9pyfun.t9PY_addr = (t9PY_index_headno[t9pyfun.firstno]+i);	//指向索引表地址

			   for (i++;i<t9PY_indexlen[t9pyfun.firstno];i++)
			   {
			   	  if (t9pyfun.t9py == (*(t9PY_index_headno[t9pyfun.firstno]+i)).t9PY)
				      t9pyfun.mblen++;
				  else 
				  	break;
			   }
			   break;
		   }
	   }

#else
 for (i=0;i<t9PY_indexlen[t9pyfun.firstno];i++)					//遍历拼音索引表	t9PY_indexlen：索引表的长度	
	   {
		   if(t9pyfun.key_len == 1)
		   {
			   t9pyfun.mblen =  t9PY_indexlen[t9pyfun.firstno];
			    flag = 0xaa;
			   t9pyfun.t9PY_addr = (t9PY_index_headno[t9pyfun.firstno]+i);	//指向索引表地址

			   break;
		   }
	   	   if (t9pyfun.t9py == (*(t9PY_index_headno[t9pyfun.firstno]+i)).t9PY)//比较索引码
		   {
		   	   t9pyfun.mblen++;												//码表长度
			   flag = 0xaa;
			   t9pyfun.t9PY_addr = (t9PY_index_headno[t9pyfun.firstno]+i);	//指向索引表地址

			   for (i++;i<t9PY_indexlen[t9pyfun.firstno];i++)
			   {
			   	  if (t9pyfun.t9py == ((*(t9PY_index_headno[t9pyfun.firstno]+i)).t9PY))
				  		t9pyfun.mblen++;
				  else if(t9pyfun.t9py ==  ((*(t9PY_index_headno[t9pyfun.firstno]+i)).t9PY)>>4)
						t9pyfun.mblen++;
				  else if(t9pyfun.t9py ==  ((*(t9PY_index_headno[t9pyfun.firstno]+i)).t9PY)>>8)
						t9pyfun.mblen++;
				  else if(t9pyfun.t9py ==  ((*(t9PY_index_headno[t9pyfun.firstno]+i)).t9PY)>>12)
						t9pyfun.mblen++;
				  else if(t9pyfun.t9py ==  ((*(t9PY_index_headno[t9pyfun.firstno]+i)).t9PY)>>16)
						t9pyfun.mblen++;
				  else if(t9pyfun.t9py ==  ((*(t9PY_index_headno[t9pyfun.firstno]+i)).t9PY)>>20)
						t9pyfun.mblen++;
				  else if(t9pyfun.t9py ==  ((*(t9PY_index_headno[t9pyfun.firstno]+i)).t9PY)>>24)
						t9pyfun.mblen++;
				  else  
				  	break;
			   }
			   break;
		   }
	   }
#endif
	   if (flag == 0x55)		   //没有查找完全对应的拼音组合，
	   {
	   	  for (i=0;i<t9PY_indexlen[t9pyfun.firstno];i++)
	   	  {
	   	      temp = (*(t9PY_index_headno[t9pyfun.firstno]+i)).t9PY;
			  while (temp > t9pyfun.t9py)
			  {
				 temp >>= 4;
				 if (temp == t9pyfun.t9py)
				 {
				 	t9pyfun.t9PY_addr = t9PY_index_headno[t9pyfun.firstno]+i;
					t9pyfun.mblen++;
					i = t9PY_indexlen[t9pyfun.firstno];
					flag = 0xaa;
					break;
				 }
			  }			 
	      }
		  if (flag == 0x55)
		  {
	   		  t9pyfun.t9py >>= 4;
		   	  t9pyfun.mblen = mblentemp;
		   }
	   }
	   
	}
	else if(t9pyfun.pysrf == T9SZ)			 //数字输入
	{
		//t9pyfun.mblen++;
		t9pyfun.t9PY_addr = &t9PY_sz[t9pyfun.firstno];
	}
	else if(t9pyfun.pysrf == T9BD)			//标点输入
	{
		//t9pyfun.mblen++;
		t9pyfun.t9PY_addr = t9PY_index0;
	} 
	else if(t9pyfun.pysrf == T9DX)			//大写英文字母输入
	{
		if ((t9pyfun.firstno>1)&&(t9pyfun.firstno<10))
		{
			//t9pyfun.mblen++;
			t9pyfun.t9PY_addr = &t9PY_ABC[t9pyfun.firstno];
		}
	} 
	else if(t9pyfun.pysrf == T9XX)			//小写英文字母输入
	{
		if ((t9pyfun.firstno>1)&&(t9pyfun.firstno<10))
		{
			//t9pyfun.mblen++;
			t9pyfun.t9PY_addr = &t9PY_abc[t9pyfun.firstno];
		}
	}
}
#endif

void PY_Disp(void)
{



}




uint16_t   straddrx;		//字符显示位置
uint16_t	 straddry;
uint16_t   t9pyaddrx;	    //拼音显示位置
uint16_t   t9pyaddry;
uint16_t   indexaddrx;	//索引显示位置
uint16_t   indexaddry;
uint8_t    indexdata;     //索引值，也即选出的字在索引表中的位置.

uint8_t    hzbuff[512];   //输入256个汉字
uint16_t   hzlen;         //输放汉字的个数
uint16_t   hzin;          //往缓冲区输入汉字的位置
uint16_t   hzout;         //从缓冲区取出汉字的位置

#define  indextablen    15  //每次显示索引处的长度，最大值为15个汉字。


/*********************************************************************************************************
** create by :           magicchip
** create data:          2008-06-04
** 输入数数: 
** 功能：    显示输入法
** 入口参数：
** 出口参数：      
**-------------------------------------------------------------------------------------------------------
** Modified by:
** Modified date:
**------------------------------------------------------------------------------------------------------
********************************************************************************************************/
#if 0
void dispsrf(void)
{
	const uint8_t *strsrf[] = {"标点","大写","小写","拼音","数字"};
	const uint8_t disp_srf[] = "输入法：";	
	
	SetFgColor(RED);
	SetBgColor(TIANLANSE);
	SetCharCoord(SRF_X,SRF_Y);	

	PrintGB((uint8_t*)disp_srf,4);
	PrintGB((uint8_t*)strsrf[t9pyfun.pysrf],2);
}
#endif
/*********************************************************************************************************
** create by :           magicchip
** create data:          2008-06-04
** 输入数数: 
** 功能：    显示字符处光标和拼音处光标
** 入口参数：
** 出口参数：      
**-------------------------------------------------------------------------------------------------------
** Modified by:
** Modified date:
**------------------------------------------------------------------------------------------------------
********************************************************************************************************/
#if 0
void dispgb(uint16_t gbchar)
{
	SetFgColor(RED);
	SetBgColor(TIANLANSE);
	SetCharCoord(straddrx,straddry);
	PrintoneASCII(gbchar);
	SetCharCoord(t9pyaddrx,t9pyaddry);
	PrintoneASCII(gbchar);
}

/*********************************************************************************************************
** create by :           magicchip
** create data:          2008-06-11
** 输入数数: 
** 功能：    显示输入的内容
** 入口参数：
** 出口参数：      
**-------------------------------------------------------------------------------------------------------
** Modified by:
** Modified date:
**------------------------------------------------------------------------------------------------------
********************************************************************************************************/
void dispsf(void)
{
	uint8_t i=0,j=0;
	SetFgColor(RED);
	SetBgColor(TIANLANSE);
	
	if (hzlen > 0)			   //缓冲区内有显示的内容
	{
		SetCharCoord(straddrx,straddry);
		while(1)
		{
			if (hzbuff[hzout] > 0x80)   //显示汉字
			{
				PrintoneGB(&hzbuff[hzout]);				
				hzout += 2;
				straddrx += 16;
				if (straddrx > 304)
				{
					straddrx = 0;
					straddry += 16;
					if (straddry > 223)
					{
						straddry = 16;
						SetFgColor(TIANLANSE);
						Draw_Rect(0x27,0,16,319,223);		//清除显示区域
						SetFgColor(TIANLANSE);
					}
					SetCharCoord(straddrx,straddry);					
				}
			}
			else if (hzbuff[hzout] > 0)  // 显示ASC
			{
				PrintoneASCII(hzbuff[hzout]);				
				hzout ++;
				straddrx += 8;
				if (straddrx > 312)
				{
					straddrx = 0;
					straddry += 16;
					if (straddry > 223)
					{
						straddry = 16;
						SetFgColor(TIANLANSE);
						Draw_Rect(0x27,0,16,319,223);		 //清除显示区域
						SetFgColor(TIANLANSE);
					}
					SetCharCoord(straddrx,straddry);					
				}
			}
			else
				break;
		}
				
	}

	t9pyaddrx = 0;	
	SetCharCoord(t9pyaddrx,t9pyaddry);
	PrintASCII("                                        ");
	if (t9pyfun.mblen > 0)            //索引内容
	{
		t9pyaddrx = 0;
		SetCharCoord(t9pyaddrx,t9pyaddry);
		while(t9pyfun.t9py >> (4*i))				  //显示索引拼音
		{
			PrintoneASCII(*((*t9pyfun.t9PY_addr).PY+i));
			i++;
			t9pyaddrx += 8;			
		}

		if (*(*t9pyfun.t9PY_addr).PY_mb > 0x80)				   //显示汉字索引列表
		{
			if (!(*((*t9pyfun.t9PY_addr).PY_mb+indexdata*2)))	//设置开始显示索引汉字的位置.
			{
				indexdata = 0;
				i = 0;
			}
			else
				i = 2*indextablen*(indexdata/indextablen);
			SetCharCoord(indexaddrx,indexaddry);		   //设置汉字索引表显示的位置.
			while(*((*t9pyfun.t9PY_addr).PY_mb+i))		   //显示索引汉字
			{
			
				if (i/2 == indexdata)
				{
				 	SetFgColor(WHITE);
				 	SetBgColor(BLACK);
				 	PrintoneGB((uint8_t*)(((*t9pyfun.t9PY_addr).PY_mb+i)));	
			     	i += 2;
				 	SetFgColor(RED);
	             	SetBgColor(TIANLANSE);
				}
				else
				{
					PrintoneGB((uint8_t*)(((*t9pyfun.t9PY_addr).PY_mb+i)));	
					i += 2;
				}			
			
				j++;		   //保证索引列表不溢出
				if (j >= indextablen)
					break;			
			}
		}
		else		//标点或大小写字母索引显示
		{
			if (!(*((*t9pyfun.t9PY_addr).PY_mb+indexdata)))	//设置开始显示索引的位置.
			{
				indexdata = 0;
				i = 0;
			}
			else
				i = 2*indextablen*(indexdata/(2*indextablen));
			SetCharCoord(indexaddrx,indexaddry);		   //设置索引表显示的位置.
			while(*((*t9pyfun.t9PY_addr).PY_mb+i))		   //显示索引字符
			{
				if (i == indexdata)
				{
				 	SetFgColor(WHITE);
				 	SetBgColor(BLACK);
					PrintoneASCII(*((*t9pyfun.t9PY_addr).PY_mb+i));	
			     	i ++;
				 	SetFgColor(RED);
	             	SetBgColor(TIANLANSE);
				}
				else
				{
					PrintoneASCII(*((*t9pyfun.t9PY_addr).PY_mb+i));
					i ++;
				}			
			
				j++;		   //保证索引列表不溢出
				if (j >= (2*indextablen))
					break;
			}
		}			
	}
}
#endif
/*********************************************************************************************************
** create by :           magicchip
** create data:          2008-06-11
** 输入数数: 
** 功能：    初始化索引量，使之清0。
** 入口参数：
** 出口参数：      
**-------------------------------------------------------------------------------------------------------
** Modified by:
** Modified date:
**------------------------------------------------------------------------------------------------------
********************************************************************************************************/
void clrindex(void)
{
	t9pyfun.pysrf = T9PY;	   //初始输入法为拼音
	t9pyfun.firstno = ' ';	   //初始输入数字按键为空
	t9pyfun.mblen = 0;		   //初始码表长度为0
	t9pyfun.mbtimes = 0;       //索引切换次数为0
	t9pyfun.t9py = 0;		   //初始按键组合为0
	t9pyfun.key_len = 0;		//按键次数为0
	indexdata = 0;
}

/*********************************************************************************************************
** create by :           magicchip
** create data:          2008-06-04
** 输入数数: 
** 功能：    汉字输入法任务
** 入口参数：
** 出口参数：      
**-------------------------------------------------------------------------------------------------------
** Modified by:
** Modified date:
**------------------------------------------------------------------------------------------------------
********************************************************************************************************/
#define KEY_JH 0x01
#define KEY_XH 0x02
#define T9N00 0x03
#define T9N01 0x04
#define KEY_LEFT 0x05
#define KEY_RIGHT 0x06
#define KEY_ENTER 0x07
#define KEY_MENU  0x08


void T9pyTask(unsigned int key)
{
	uint16_t i;


	hzlen = 0;
	hzin = 0;
	hzout = 0;
	for (i=0;i<512;i++)
	hzbuff[i] = 0x00;

	straddrx = 0;
	straddry = 16;
	t9pyaddrx = 0;
	t9pyaddry = 224;
	indexaddrx = 80;	//索引显示位置
    indexaddry = 224;

	if (((uint32_t)key>=0x30) &&((uint32_t)key<=0x39))	  //输入内容
	{
		if (t9pyfun.pysrf == T9PY)
		{
			if (((uint32_t)key>=0x32) &&((uint32_t)key<=0x39))	  //输入内容
			{
				t9pyfun.mbtimes = 0;
				indexdata = 0;
				if (t9pyfun.firstno == ' ')
					t9pyfun.firstno = (uint32_t)key-0x30;
				t9pyfun.t9py = ((t9pyfun.t9py<<4) | ((uint32_t)key - 0x30));

				t9pyfun.key_len++;
				py_index_sub();
						
			}
		}
		else if(t9pyfun.pysrf == T9SZ)
		{
			
			t9pyfun.firstno = (uint32_t)key-0x30;
			py_index_sub();	
		}
		else if(t9pyfun.pysrf == T9DX)
		{
			
			t9pyfun.firstno = (uint32_t)key-0x30;
			py_index_sub();	
		}
		else if(t9pyfun.pysrf == T9XX)
		{
			
			t9pyfun.firstno = (uint32_t)key-0x30;
			py_index_sub();	
		}
	}
}
	

